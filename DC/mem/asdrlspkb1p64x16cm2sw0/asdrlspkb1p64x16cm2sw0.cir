**
.global VSS
.global VDD
*---------------------------------------------------------------------*
*               Copyright(c) Synopsys, Inc.                           *
*     All Rights reserved - Unpublished -rights reserved under        *
*     the Copyright laws of the United States of America.             *
*                                                                     *
*  U.S. Patents: 7,093,156 B1 and 7,406,620 B2 (and more pending).    *
*                                                                     *
*  This file includes the Confidential information of Synopsys, Inc.  *
*  and Huali.                                                         *
*  The receiver of this Confidential Information shall not disclose   *
*  it to any third party and shall protect its confidentiality by     *
*  using the same degree of care, but not less than a reasonable      *
*  degree of care, as the receiver uses to protect receiver's own     *
*  Confidential Information.                                          *
*  Licensee acknowledges and agrees that all output generated for     *
*  Licensee by Synopsys, Inc. as described in the pertinent Program   *
*  Schedule(s), or generated by Licensee through use of any Compiler  *
*  licensed hereunder contains information that complies with the     *
*  Virtual Component Identification Physical Tagging Standard (VCID)  *
*  as maintained by the Virtual Socket Interface Alliance (VSIA).     *
*  Such information may be expressed in GDSII Layer 63 or other such  *
*  layer designated by the VSIA, hardware definition languages, or    *
*  other formats.  Licensee is not authorized to alter or change any  *
*  such information.                                                  *
*---------------------------------------------------------------------*
*                                                                     *
*  Built for linux64 and running on linux64.                          *
*                                                                     *
*  Software           : Rev: S-2021.12                                *
*  Library Format     : Rev: 1.05.00                                  *
*  Compiler Name      : hu55npkb1p11asdrl32ksa03p1                    *
*  Platform           : Linux3.10.0-1160.49.1.el7.x86_64              *
*                     : #1 SMP Tue Nov 30 15:51:32 UTC 2021x86_64     *
*  Date of Generation : Fri Feb 18 10:17:43 CST 2022                  *
*                                                                     *
*---------------------------------------------------------------------*
*
*--------------------------------------------- HEAD.TXT
*.GLOBAL VSS VDD VSS
.PARAM me84a03_LPD=0.06U
.PARAM me84a03_LND=0.06U
.PARAM me84a03_LD=0.06U
.PARAM me84a03_WPD=99
.PARAM me84a03_WND=99
.PARAM DEFMUL=1
.PARAM ARD=0.0595P PRD=1.04U
.OPTION SCALE=1
******** BASED ON 0.525 SQ.M BIT-CELL
.PARAM L1PD=0.065U L1PU=0.065U L1PG=0.075U
.PARAM W1PD=0.145U W1PU=0.085U W1PG=0.095U
*.EQUIV P=PM N=NM
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*-------------------------------------- END OF HEAD.TXT
*

* SPICE NETLIST
***************************************

.SUBCKT npd D G S B
.ENDS
***************************************
.SUBCKT npg D G S B
.ENDS
***************************************
.SUBCKT ppu D G S B
.ENDS
***************************************
.SUBCKT dp_npd D G S B
.ENDS
***************************************
.SUBCKT dp_npg1 D G S B
.ENDS
***************************************
.SUBCKT dp_npg2 D G S B
.ENDS
***************************************
.SUBCKT dp_ppu D G S B
.ENDS
***************************************
.SUBCKT n12_lp D G S B
.ENDS
***************************************
.SUBCKT p12_lp D G S B
.ENDS
***************************************
.SUBCKT nlvt12_lp D G S B
.ENDS
***************************************
.SUBCKT plvt12_lp D G S B
.ENDS
***************************************
.SUBCKT nhvt12_lp D G S B
.ENDS
***************************************
.SUBCKT phvt12_lp D G S B
.ENDS
***************************************
.SUBCKT nt12_lp D G S B
.ENDS
***************************************
.SUBCKT n25_lp D G S B
.ENDS
***************************************
.SUBCKT p25_lp D G S B
.ENDS
***************************************
.SUBCKT n25od33_lp D G S B
.ENDS
***************************************
.SUBCKT p25od33_lp D G S B
.ENDS
***************************************
.SUBCKT nt25_lp D G S B
.ENDS
***************************************
.SUBCKT pnp12a4_lp C B E
.ENDS
***************************************
.SUBCKT pnp12a25_lp C B E
.ENDS
***************************************
.SUBCKT pnp12a100_lp C B E
.ENDS
***************************************
.SUBCKT npn12a4_lp C B E
.ENDS
***************************************
.SUBCKT npn12a25_lp C B E
.ENDS
***************************************
.SUBCKT npn12a100_lp C B E
.ENDS
***************************************
.SUBCKT pnp25a4_lp C B E
.ENDS
***************************************
.SUBCKT pnp25a25_lp C B E
.ENDS
***************************************
.SUBCKT pnp25a100_lp C B E
.ENDS
***************************************
.SUBCKT npn25a4_lp C B E
.ENDS
***************************************
.SUBCKT npn25a25_lp C B E
.ENDS
***************************************
.SUBCKT npn25a100_lp C B E
.ENDS
***************************************
.SUBCKT res_ndif plus minus b
.ENDS
***************************************
.SUBCKT res_pdif plus minus b
.ENDS
***************************************
.SUBCKT res_npo plus minus b
.ENDS
***************************************
.SUBCKT res_ppo plus minus b
.ENDS
***************************************
.SUBCKT res_ndifsab plus minus b
.ENDS
***************************************
.SUBCKT res_pdifsab plus minus b
.ENDS
***************************************
.SUBCKT res_nposab plus minus b
.ENDS
***************************************
.SUBCKT res_pposab plus minus b
.ENDS
***************************************
.SUBCKT res_nwaa plus minus b
.ENDS
***************************************
.SUBCKT res_nwsti plus minus b
.ENDS
***************************************
.SUBCKT res_m1 plus minus b
.ENDS
***************************************
.SUBCKT res_m2 plus minus b
.ENDS
***************************************
.SUBCKT res_m3 plus minus b
.ENDS
***************************************
.SUBCKT res_m4 plus minus b
.ENDS
***************************************
.SUBCKT res_m5 plus minus b
.ENDS
***************************************
.SUBCKT res_m6 plus minus b
.ENDS
***************************************
.SUBCKT res_m7 plus minus b
.ENDS
***************************************
.SUBCKT res_t2m1 plus minus b
.ENDS
***************************************
.SUBCKT res_t4m1 plus minus b
.ENDS
***************************************
.SUBCKT res_t4m2 plus minus b
.ENDS
***************************************
.SUBCKT res_alpa plus minus b
.ENDS
***************************************
.SUBCKT MOM12_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM13_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM14_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM15_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM16_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM23_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM24_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM25_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM26_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM34_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM35_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM36_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM45_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM46_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM56_3T plus minus B
.ENDS
***************************************
.SUBCKT MOM12 plus minus
.ENDS
***************************************
.SUBCKT MOM13 plus minus
.ENDS
***************************************
.SUBCKT MOM14 plus minus
.ENDS
***************************************
.SUBCKT MOM15 plus minus
.ENDS
***************************************
.SUBCKT MOM16 plus minus
.ENDS
***************************************
.SUBCKT MOM23 plus minus
.ENDS
***************************************
.SUBCKT MOM24 plus minus
.ENDS
***************************************
.SUBCKT MOM25 plus minus
.ENDS
***************************************
.SUBCKT MOM26 plus minus
.ENDS
***************************************
.SUBCKT MOM34 plus minus
.ENDS
***************************************
.SUBCKT MOM35 plus minus
.ENDS
***************************************
.SUBCKT MOM36 plus minus
.ENDS
***************************************
.SUBCKT MOM45 plus minus
.ENDS
***************************************
.SUBCKT MOM46 plus minus
.ENDS
***************************************
.SUBCKT MOM56 plus minus
.ENDS
***************************************
.SUBCKT mim_1 plus minus
.ENDS
***************************************
.SUBCKT mim_1d5 plus minus
.ENDS
***************************************
.SUBCKT mim_2 plus minus
.ENDS
***************************************
.SUBCKT n12var_lp plus minus B
.ENDS
***************************************
.SUBCKT p12var_lp plus minus B
.ENDS
***************************************
.SUBCKT p12vardn_lp plus minus DN B
.ENDS
***************************************
.SUBCKT n25var_lp plus minus B
.ENDS
***************************************
.SUBCKT p25var_lp plus minus B
.ENDS
***************************************
.SUBCKT p25vardn_lp plus minus DN B
.ENDS

*CUSTOM DESIGNER (TM) VERSION I-2013.12-SP1
*WED MAY 28 10:48:16 2014

*****************************************************************************
* GLOBAL NET DECLARATIONS
*****************************************************************************
*.GLOBAL VSS VDD VDD VSS

*****************************************************************************
* PIN CONTROL STATEMENT
*****************************************************************************
*.PIN VSS VDD VDD VSS

*****************************************************************************
* BIPOLAR DECLARATIONS
*****************************************************************************
*.BIPOLAR
*.RESI = 2000.000000
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.SCALE METER

*****************************************************************************
* PARAMETER STATEMENT
*****************************************************************************
.PARAM

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_TG                                                                   *
* LAST TIME SAVED:  MAR 24 13:46:45 2014                                      *
*******************************************************************************
.SUBCKT me84a03_TG A Z CK CKB LN=me84a03_LND LP=me84a03_LPD WN=me84a03_WND WP=me84a03_WPD
*.PININFO A:B Z:B CK:I CKB:I
XMPSB Z CKB A VDD P12_LP W=WP L=LP M=1
XMNS A CK Z VSS N12_LP W=WN L=LN M=1
.ENDS me84a03_TG

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_INV                                                                  *
* LAST TIME SAVED:  APR 23 11:27:33 2014                                      *
*******************************************************************************
.SUBCKT me84a03_INV QN A LN=me84a03_LND LP=me84a03_LPD WN=me84a03_WND WP=me84a03_WPD
*.PININFO QN:O A:I
XMNA QN A VSS VSS N12_LP W=WN L=LN M=1
XMPA VDD A QN VDD P12_LP W=WP L=LP M=1
.ENDS me84a03_INV

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ND2                                                                  *
* LAST TIME SAVED:  MAR 24 13:46:44 2014                                      *
*******************************************************************************
.SUBCKT me84a03_ND2 Z A B LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD
+LP2=me84a03_LPD WN1=me84a03_WND WN2=me84a03_WND WP1=me84a03_WPD WP2=me84a03_WPD
*.PININFO Z:O A:I B:I
XMNA1 Z A NET19 VSS N12_LP W=WN1 L=LN1 M=1
XMNA2 NET19 B VSS VSS N12_LP W=WN2 L=LN2 M=1
XMPA1 VDD A Z VDD P12_LP W=WP1 L=LP1 M=1
XMPA2 VDD B Z VDD P12_LP W=WP2 L=LP2 M=1
.ENDS me84a03_ND2

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_STGENWR                                                              *
* LAST TIME SAVED:  MAY 08 15:23:12 2014                                      *
*******************************************************************************
.SUBCKT me84a03_STGENWR STCWR RBL WRREF CCWR CCWRT LOG1 RW_RBL STCLKB LN=me84a03_LND LN1=me84a03_LND
+LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO STCWR:O RBL:B WRREF:B CCWR:I CCWRT:I LOG1:I RW_RBL:I STCLKB:I
XIQ0 STCMX WRREF RW_RBLB RW_RBL me84a03_TG WN=0.35U WP=1.0U
XI913 STCMX STCLKB RW_RBL RW_RBLB me84a03_TG WN=0.35U WP=1.0U
XMI38 VDD CCWRT RBL VDD P12_LP W=1.0U L=me84a03_LD M=1
XMI37 VSS LOG1 WRT VSS N12_LP W=2.0U L=me84a03_LD M=1
XMI36 RBL CCWRT WRT VSS N12_LP W=1.89U L=0.08U
XI53 RW_RBLB RW_RBL me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI47 STCWR STCMX CCWR me84a03_ND2 WN1=3.5U WN2=3.5U WP1=1.8U WP2=1.8U
.ENDS me84a03_STGENWR

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DLYND2                                                               *
* LAST TIME SAVED:  MAY 08 15:23:04 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DLYND2 DO DI P LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO DO:O DI:I P:I
XI356 DIB1 DI me84a03_INV LN=0.08U LP=0.08U WN=0.2U WP=0.2U
XI0 DO DIB1 P me84a03_ND2 LN1=0.08U LN2=0.08U LP1=0.08U LP2=0.08U WN1=0.2U WN2=0.2U WP1=0.2U
+ WP2=0.2U
.ENDS me84a03_DLYND2

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DLY2                                                                 *
* LAST TIME SAVED:  MAY 08 15:23:13 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DLY2 DO DI
*.PININFO DO:O DI:I
XI409 DO DIB1 me84a03_INV LN=0.08U LP=0.08U WN=0.2U WP=0.2U
XI356 DIB1 DI me84a03_INV LN=0.08U LP=0.08U WN=0.2U WP=0.2U
.ENDS me84a03_DLY2

.SUBCKT me84a03_DLY2_2 DO DI
*.PININFO DO:O DI:I
XI409 DO DIB1 me84a03_INV LN=0.08U LP=0.08U WN=0.2U WP=0.4U
XI356 DIB1 DI me84a03_INV LN=0.08U LP=0.08U WN=0.2U WP=0.2U
.ENDS me84a03_DLY2_2

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CC_LOOP2                                                             *
* LAST TIME SAVED:  MAY 08 15:23:07 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CC_LOOP2 RREF PRCLK Z0 LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO RREF:B PRCLK:I Z0:I
XI5 CC4DEL NET49 Z0 me84a03_DLYND2
XI16 NET018 NET024 me84a03_DLY2
XI14 NET024 PRCLK me84a03_DLY2_2
XI7 NET47 NET018 me84a03_DLY2
XI6 NET49 NET47 me84a03_DLY2
XI56 RREF CC4DEL NET024 me84a03_ND2 LN1=0.08U LN2=0.08U LP1=0.08U LP2=0.08U WN1=0.8U WN2=0.8U
+ WP1=0.2U WP2=0.2U
.ENDS me84a03_CC_LOOP2

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_NR2                                                                  *
* LAST TIME SAVED:  APR 23 17:27:47 2014                                      *
*******************************************************************************
.SUBCKT me84a03_NR2 Z A B LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD
+LP2=me84a03_LPD WN1=me84a03_WND WN2=me84a03_WND WP1=me84a03_WPD WP2=me84a03_WPD
*.PININFO Z:O A:I B:I
XMNA1 Z B VSS VSS N12_LP W=WN1 L=LN1 M=1
XMNA2 Z A VSS VSS N12_LP W=WN2 L=LN2 M=1
XMPA2 VDD A NET10 VDD P12_LP W=WP2 L=LP2 M=1
XMPA1 NET10 B Z VDD P12_LP W=WP1 L=LP1 M=1
.ENDS me84a03_NR2

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IMUX2ST                                                              *
* LAST TIME SAVED:  MAY 08 15:23:07 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IMUX2ST O A B C LN=me84a03_LND LP=me84a03_LPD
*.PININFO O:O A:I B:I C:I
XISEL NET5 C me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.21U WP=0.21U
XIPASS0 A O NET5 C me84a03_TG LN=me84a03_LD LP=me84a03_LD WN=2.93U WP=0.5U
XIPASS1 B O C NET5 me84a03_TG LN=me84a03_LD LP=me84a03_LD WN=2.0U WP=0.5U
.ENDS me84a03_IMUX2ST

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RIO_LOGIC1                                                           *
* LAST TIME SAVED:  MAY 08 15:22:56 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RIO_LOGIC1 BCB BCT CCOR CCRD CCWR DCLKB LOG0 LOG1 LWE MCLK PCB0 PCB1
+ PCB2 PCB3 RBLWR RW_RBL SAEBR SAEBRT SAOFF STCLK STCLKWR SWBAWT SWBAWTB T1B
+ WRREF Z0B LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BCB:B BCT:B CCOR:I CCRD:B CCWR:I DCLKB:B LOG0:B LOG1:B LWE:B MCLK:I PCB0:B
*.PININFO PCB1:B PCB2:B PCB3:B RBLWR:I RW_RBL:I SAEBR:O SAEBRT:O SAOFF:I STCLK:O
*.PININFO STCLKWR:O SWBAWT:B SWBAWTB:B T1B:I WRREF:I Z0B:I
XI42 STCLKWR RBLWR WRREF CCWR CCWR LOG1 RW_RBL NET80 me84a03_STGENWR
XI3 RREF CCORW Z0B me84a03_CC_LOOP2
XI45 NET74 CCWR CCOR me84a03_NR2 WN1=0.3U WN2=0.3U WP1=0.6U WP2=0.6U
XI68 NET80 T1T RREF me84a03_NR2 WN1=1.2U WN2=1.2U WP1=2.8U WP2=2.8U
XI0 SAEBRT SAOFF STCLKMUX me84a03_NR2 WN1=1.6U WN2=1.6U WP1=10U WP2=10U
XI46 CCORW NET74 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.6U
XI22 SAEBR SAEBRT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=8.8U WP=5.2U
XI56 T1T T1B me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.5U WP=1.0U
XI28 STCLKMUX STCLK MCLK T1T me84a03_IMUX2ST
XI61 STCLK NET80 CCOR me84a03_ND2 WN1=4.2U WN2=4.2U WP1=2.1U WP2=2.1U
.ENDS me84a03_RIO_LOGIC1

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RIO_LOGIC1_LITE                                                      *
* LAST TIME SAVED:  MAY 08 15:23:09 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RIO_LOGIC1_LITE CCOR CCRD CCWR DCLKB LOG0 LOG1 LWE MCLK PCB0 PCB1
+PCB2 PCB3 RBLWR RW_RBL SAEBR SAEBRT SAOFF STCLK STCLKWR T1B WRREF Z0B LN=me84a03_LND
+ LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO CCOR:I CCRD:B CCWR:I DCLKB:B LOG0:B LOG1:B LWE:B MCLK:I PCB0:B PCB1:B
*.PININFO PCB2:B PCB3:B RBLWR:I RW_RBL:I SAEBR:O SAEBRT:O SAOFF:I STCLK:O STCLKWR:O
*.PININFO T1B:I WRREF:I Z0B:I
XI42 STCLKWR RBLWR WRREF CCWR CCWR LOG1 RW_RBL NET80 me84a03_STGENWR
XI3 RREF CCORW Z0B me84a03_CC_LOOP2
XI45 NET74 CCWR CCOR me84a03_NR2 WN1=0.3U WN2=0.3U WP1=0.6U WP2=0.6U
XI68 NET80 T1T RREF me84a03_NR2 WN1=1.2U WN2=1.2U WP1=2.8U WP2=2.8U
XI0 SAEBRT SAOFF STCLKMUX me84a03_NR2 WN1=1.6U WN2=1.6U WP1=10U WP2=10U
XI46 CCORW NET74 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.6U
XI22 SAEBR SAEBRT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=8.8U WP=5.2U
XI56 T1T T1B me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.5U WP=1.0U
XI28 STCLKMUX STCLK MCLK T1T me84a03_IMUX2ST
XI61 STCLK NET80 CCOR me84a03_ND2 WN1=4.2U WN2=4.2U WP1=2.1U WP2=2.1U
.ENDS me84a03_RIO_LOGIC1_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ALL32A@SHEET002                                                      *
* LAST TIME SAVED:  MAY 08 15:22:53 2014                                      *
*******************************************************************************
.SUBCKT me84a03_ALL32A@SHEET002 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
XI657 NET48 NET49 NET66 NET46 NET65 NET52 NET43 NET44 NET50 NET74 NET450
+NET451 NET452 NET453 NET61 NET72 NET47 NET69 NET70 NET67 NET68 NET51
+NET53 NET71 NET63 NET73 me84a03_RIO_LOGIC1
XI659 NET76 NET57 NET75 NET60 NET54 NET55 NET59 NET84 NET560 NET561 NET562
+NET563 NET62 NET82 NET58 NET79 NET80 NET77 NET78 NET81 NET64 NET83
+me84a03_RIO_LOGIC1_LITE
.ENDS me84a03_ALL32A@SHEET002

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_SA_DO1                                                               *
* LAST TIME SAVED:  MAY 08 15:23:00 2014                                      *
*******************************************************************************
.SUBCKT me84a03_SA_DO1 QT SQB SQT LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO QT:B SQB:I SQT:I
XI1 QT SQB NET16 me84a03_ND2 WN1=0.8U WN2=0.8U WP1=0.4U WP2=0.4U
XI0 NET16 SQT QT me84a03_ND2 WN1=0.8U WN2=0.8U WP1=0.6U WP2=0.6U
.ENDS me84a03_SA_DO1

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_LSA1                                                                 *
* LAST TIME SAVED:  MAY 08 15:22:55 2014                                      *
*******************************************************************************
.SUBCKT me84a03_LSA1 QB QT BL BLB SAEN SAEP SAPR
*.PININFO QB:O QT:O BL:I BLB:I SAEN:I SAEP:I SAPR:I
XMI5 QT QB VDD VDD P12_LP W=0.37U L=0.08U M=2
XMI348 QB QT VDD VDD P12_LP W=0.37U L=0.08U M=2
XMI335 QB QT SAEB VSS N12_LP W=0.8U L=0.16U M=2
XMI1 SAEB SAEN VSS VSS N12_LP W=0.72U L=me84a03_LD
XMI4 QT QB SAEB VSS N12_LP W=0.8U L=0.16U M=2
XMI929 QB SAPR QT VDD P12_LP W=0.21U L=me84a03_LD M=1
XMI960 QB SAPR VDD VDD P12_LP W=0.21U L=me84a03_LD M=1
XMI965 QT SAPR VDD VDD P12_LP W=0.21U L=me84a03_LD M=1
XMI952 BLB SAEP QB VDD P12_LP W=0.37U L=me84a03_LD M=2
XMI6 BL SAEP QT VDD P12_LP W=0.37U L=me84a03_LD M=2
.ENDS me84a03_LSA1

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DO2_LITE                                                             *
* LAST TIME SAVED:  MAY 08 15:23:11 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DO2_LITE D_AH Q D LQT
*.PININFO D_AH:O Q:O D:I LQT:I
XI36 D_AH NET18 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
XI30 NET21 LQT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.38U WP=.76U
XI29 Q NET21 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.2U WP=2.4U
XI37 NET18 D me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
.ENDS me84a03_DO2_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CINV                                                                 *
* LAST TIME SAVED:  APR 25 12:32:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CINV QN A CK CKB LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD
+LP2=me84a03_LPD WN1=me84a03_WND WN2=me84a03_WND WP1=me84a03_WPD
+ WP2=me84a03_WPD
*.PININFO QN:B A:I CK:I CKB:I
XMPA VDD A NET16 VDD P12_LP W=WP1 L=LP1 M=1
XMPS1 NET16 CKB QN VDD P12_LP W=WP2 L=LP2 M=1
XMNA NET020 A VSS VSS N12_LP W=WN2 L=LN2 M=1
XMNS0 QN CK NET020 VSS N12_LP W=WN1 L=LN1 M=1
.ENDS me84a03_CINV

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_L2BIO                                                                *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_L2BIO QB CB CT IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO QB:O CB:I CT:I IN:I
XXG1 IN INB CB CT me84a03_TG LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI13 INB QB CT CB me84a03_CINV WN1=0.17U WN2=0.17U WP1=0.17U WP2=0.17U
XXII QB INB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
.ENDS me84a03_L2BIO

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WRDRV2_LITE                                                          *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WRDRV2_LITE WRB WRT DCLKB D_AH LWE LN=me84a03_LND
+LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD
+ LP2=me84a03_LPD
*.PININFO WRB:O WRT:O DCLKB:I D_AH:I LWE:I
XXDA LDIT DICB DICT DIB me84a03_L2BIO
XI29 NET21 NET076 LDIB me84a03_NR2 LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U WP1=0.3U
+ WP2=0.3U
XI28 NET24 NET076 NET064 me84a03_NR2 LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U
+WP1=0.3U WP2=0.3U
XI6 NET51 D_AH me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI7 NET49 NET51 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI8 DIB NET49 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI15 NET064 LDIB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XXID LDIB LDIT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI16 WRT NET24 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.01U WP=0.6U
XI17 WRB NET21 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.01U WP=0.6U
XI40 DICB DICT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI42 NET076 LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI41 DICT DCLKB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.3U
.ENDS me84a03_WRDRV2_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CMUX                                                                 *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CMUX BB BT RDB RDT WRB WRT PCB
*.PININFO BB:B BT:B RDB:B RDT:B WRB:B WRT:B PCB:I
XMP2 VDD PRCHB BB VDD P12_LP W=0.9U L=me84a03_LD M=1
XMP1 VDD PRCHB BT VDD P12_LP W=0.9U L=me84a03_LD M=1
XMP3 BT PRCHB BB VDD P12_LP W=0.9U L=me84a03_LD M=1
XMP5 BB NET48 RDB VDD P12_LP W=0.6U L=me84a03_LD M=1
XMP4 BT NET48 RDT VDD P12_LP W=0.6U L=me84a03_LD M=1
XMN2 BB PRCHB WRB VSS N12_LP W=1.89U L=0.08U M=1
XMN1 BT PRCHB WRT VSS N12_LP W=1.89U L=0.08U M=1
XI3 PRCHB NET48 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.7U WP=0.7U
XI16 NET48 PCB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.50U
.ENDS me84a03_CMUX

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CMUX2                                                                *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CMUX2 BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0
*.PININFO BB1:B BB0:B BT1:B BT0:B RDB:B RDT:B WRB:B WRT:B PCB1:I PCB0:I
XX0 BB0 BT0 RDB RDT WRB WRT PCB0 me84a03_CMUX
XXM BB1 BT1 RDB RDT WRB WRT PCB1 me84a03_CMUX
.ENDS me84a03_CMUX2

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2_LITE                                                           *
* LAST TIME SAVED:  MAY 08 15:22:55 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2_LITE BB0 BB1 BT0 BT1 CCRD DA DCLKB LOG0 LOG1 LWE0 LWE1
+ PCB0 PCB1 Q SAEB LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE0:I
*.PININFO LWE1:I PCB0:B PCB1:B Q:O SAEB:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET028 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
DI34 VSS DA NDIO12_LP AREA=ARD PJ=PRD
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET029 CCRD me84a03_LSA1
XI31 NET20 Q DA LQT me84a03_DO2_LITE
XXDI WRB WRT DCLKB NET20 LWE0 me84a03_WRDRV2_LITE
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2
XI36 NET029 SAEB NET028 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_BEMXIO                                                               *
* LAST TIME SAVED:  MAY 08 15:23:07 2014                                      *
*******************************************************************************
.SUBCKT me84a03_BEMXIO QB QT A BCB BCT TA
*.PININFO QB:O QT:O A:I BCB:I BCT:I TA:I
XMI3 QB A NA VSS N12_LP W=0.17U L=me84a03_LD M=1
XMI20 QB TA NT VSS N12_LP W=0.17U L=me84a03_LD M=1
XMI19 NT BCT VSS VSS N12_LP W=0.17U L=me84a03_LD M=1
XMI4 NA BCB VSS VSS N12_LP W=0.17U L=me84a03_LD M=1
XMI1 VDD BCT PA VDD P12_LP W=0.34U L=me84a03_LD M=1
XMI18 VDD BCB PT VDD P12_LP W=0.34U L=me84a03_LD M=1
XMI17 PT TA QB VDD P12_LP W=0.34U L=me84a03_LD M=1
XMI2 PA A QB VDD P12_LP W=0.34U L=me84a03_LD M=1
XI7 QT QB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
.ENDS me84a03_BEMXIO

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CINVW                                                                *
* LAST TIME SAVED:  MAY 07 12:39:31 2013                                      *
*******************************************************************************
.SUBCKT me84a03_CINVW QN A CK CKB LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD
+LP2=me84a03_LPD WN1=me84a03_WND WN2=me84a03_WND WP1=me84a03_WPD
+ WP2=me84a03_WPD
*.PININFO QN:O A:I CK:I CKB:I
XMTP2 VDD CKB PP0 VDD P12_LP W=WP2 L=LP2 M=1
XMTP1 PP0 A QN VDD P12_LP W=WP1 L=LP1 M=1
XMTN1 QN A NN0 VSS N12_LP W=WN1 L=LN1 M=1
XMTN2 NN0 CK VSS VSS N12_LP W=WN2 L=LN2 M=1
.ENDS me84a03_CINVW

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DO2                                                                  *
* LAST TIME SAVED:  MAY 08 15:23:02 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DO2 D_AH Q BCB BCT DA LQT SWBAWT SWBAWTB TDA LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD
+LP2=me84a03_LPD
*.PININFO D_AH:O Q:O BCB:I BCT:I DA:I LQT:I SWBAWT:I SWBAWTB:I TDA:I
XI25 NET38 D_AH DA BCB BCT TDA me84a03_BEMXIO
XI57 QB D_AH SWBAWT SWBAWTB me84a03_CINVW WN1=0.2U WN2=0.2U WP1=0.4U WP2=0.4U
XI97 QB LQT SWBAWTB SWBAWT me84a03_CINVW WN1=0.76U WN2=0.76U WP1=1.0U WP2=1.0U
XI4 Q QB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.2U WP=2.4U
.ENDS me84a03_DO2

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2                                                                *
* LAST TIME SAVED:  MAY 08 15:22:59 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2 BB0 BB1 BCB BCT BT0 BT1 CCRD DA DCLKB LOG0 LOG1 LWE0
+LWE1 PCB0 PCB1 Q SAEB SWBAWT SWBAWTB TDA LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD
+LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BCB:I BCT:I BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B
*.PININFO LWE0:I LWE1:I PCB0:B PCB1:B Q:O SAEB:I SWBAWT:I SWBAWTB:I TDA:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET043 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
DI34 VSS TDA NDIO12_LP AREA=ARD PJ=PRD
DI30 VSS DA NDIO12_LP AREA=ARD PJ=PRD
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET044 CCRD me84a03_LSA1
XXDI WRB WRT DCLKB NET31 LWE0 me84a03_WRDRV2_LITE
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2
XXDO NET31 Q BCB BCT DA LQT SWBAWT SWBAWTB TDA me84a03_DO2
XI36 NET044 SAEB NET043 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_INVH                                                                 *
* LAST TIME SAVED:  APR 02 12:24:04 2014                                      *
*******************************************************************************
.SUBCKT me84a03_INVH QN A LN=me84a03_LND LP=me84a03_LPD WN=me84a03_WND WP=me84a03_WPD
*.PININFO QN:O A:I
XMTP1 VDD A QN VDD PHVT12_LP W=WP L=LP M=1
XMTN1 QN A VSS VSS NHVT12_LP W=WN L=LN M=1
.ENDS me84a03_INVH

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_NR2H                                                                 *
* LAST TIME SAVED:  APR 02 12:26:08 2014                                      *
*******************************************************************************
.SUBCKT me84a03_NR2H Z A B LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD
+LP2=me84a03_LPD WN1=me84a03_WND WN2=me84a03_WND WP1=me84a03_WPD WP2=me84a03_WPD
*.PININFO Z:O A:I B:I
XMTN1 Z B VSS VSS NHVT12_LP W=WN1 L=LN1 M=1
XMTN2 Z A VSS VSS NHVT12_LP W=WN2 L=LN2 M=1
XMTP1 N1 B Z VDD PHVT12_LP W=WP1 L=LP1 M=1
XMTP2 VDD A N1 VDD PHVT12_LP W=WP2 L=LP2 M=1
.ENDS me84a03_NR2H

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WRDRV2_LITE_LC                                                       *
* LAST TIME SAVED:  MAY 08 15:23:08 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WRDRV2_LITE_LC WRB WRT DCLKB D_AH LWE LN=me84a03_LND LN1=me84a03_LND
+LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO WRB:O WRT:O DCLKB:I D_AH:I LWE:I
XI42 NET076 LWE me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI15 NET064 LDIB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XXID LDIB LDIT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI16 WRT NET24 me84a03_INVH LN=0.07U LP=me84a03_LD WN=2.31U WP=0.6U
XI17 WRB NET21 me84a03_INVH LN=0.07U LP=me84a03_LD WN=2.31U WP=0.6U
XI40 DICB DICT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI41 DICT DCLKB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.3U
XXDA LDIT DICB DICT DIB me84a03_L2BIO
XI29 NET21 NET076 LDIB me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U WP1=0.3U
+ WP2=0.3U
XI28 NET24 NET076 NET064 me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U
+WP1=0.3U WP2=0.3U
XI6 NET51 D_AH me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI7 NET49 NET51 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI8 DIB NET49 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
.ENDS me84a03_WRDRV2_LITE_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CINVWH                                                               *
* LAST TIME SAVED:  APR 02 12:24:39 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CINVWH QN A CK CKB LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD
+LP2=me84a03_LPD WN1=me84a03_WND WN2=me84a03_WND WP1=me84a03_WPD
+ WP2=me84a03_WPD
*.PININFO QN:O A:I CK:I CKB:I
XMTP2 VDD CKB PP0 VDD PHVT12_LP W=WP2 L=LP2 M=1
XMTP1 PP0 A QN VDD PHVT12_LP W=WP1 L=LP1 M=1
XMTN1 QN A NN0 VSS NHVT12_LP W=WN1 L=LN1 M=1
XMTN2 NN0 CK VSS VSS NHVT12_LP W=WN2 L=LN2 M=1
.ENDS me84a03_CINVWH

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_BEMXIOH                                                              *
* LAST TIME SAVED:  MAY 08 15:23:03 2014                                      *
*******************************************************************************
.SUBCKT me84a03_BEMXIOH QB QT A BCB BCT TA
*.PININFO QB:O QT:O A:I BCB:I BCT:I TA:I
XMI3 QB A NA VSS NHVT12_LP W=0.17U L=me84a03_LD M=1
XMI20 QB TA NT VSS NHVT12_LP W=0.17U L=me84a03_LD M=1
XMI19 NT BCT VSS VSS NHVT12_LP W=0.17U L=me84a03_LD M=1
XMI4 NA BCB VSS VSS NHVT12_LP W=0.17U L=me84a03_LD M=1
XMI1 VDD BCT PA VDD PHVT12_LP W=0.34U L=me84a03_LD M=1
XMI18 VDD BCB PT VDD PHVT12_LP W=0.34U L=me84a03_LD M=1
XMI17 PT TA QB VDD PHVT12_LP W=0.34U L=me84a03_LD M=1
XMI2 PA A QB VDD PHVT12_LP W=0.34U L=me84a03_LD M=1
XI7 QT QB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
.ENDS me84a03_BEMXIOH

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DO2_LC                                                               *
* LAST TIME SAVED:  MAY 08 15:23:07 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DO2_LC D_AH Q BCB BCT DA LQT SWBAWT SWBAWTB TDA LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD
+LP2=me84a03_LPD
*.PININFO D_AH:O Q:O BCB:I BCT:I DA:I LQT:I SWBAWT:I SWBAWTB:I TDA:I
XI57 QB D_AH SWBAWT SWBAWTB me84a03_CINVWH WN1=0.2U WN2=0.2U WP1=0.4U WP2=0.4U
XI97 QB LQT SWBAWTB SWBAWT me84a03_CINVWH WN1=0.76U WN2=0.76U WP1=1.0U WP2=1.0U
XI25 NET22 D_AH DA BCB BCT TDA me84a03_BEMXIOH
XI4 Q QB me84a03_INVH LN=0.07U LP=0.07U WN=1.4U WP=2.8U
.ENDS me84a03_DO2_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2_LC                                                             *
* LAST TIME SAVED:  MAY 08 15:22:57 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2_LC BB0 BB1 BCB BCT BT0 BT1 CCRD DA DCLKB LOG0 LOG1 LWE0
+LWE1 PCB0 PCB1 Q SAEB SWBAWT SWBAWTB TDA LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD
+LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BCB:I BCT:I BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B
*.PININFO LWE0:I LWE1:I PCB0:B PCB1:B Q:O SAEB:I SWBAWT:I SWBAWTB:I TDA:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET039 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET040 CCRD me84a03_LSA1
XXDI WRB WRT DCLKB NET31 LWE0 me84a03_WRDRV2_LITE_LC
DI34 VSS TDA HVTNDIO12_LP AREA=ARD PJ=PRD
DI30 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2
XXDO NET31 Q BCB BCT DA LQT SWBAWT SWBAWTB TDA me84a03_DO2_LC
XI36 NET040 SAEB NET039 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WRDRV2_LITE_LC_8                                                     *
* LAST TIME SAVED:  MAY 08 15:23:12 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WRDRV2_LITE_LC_8 WRB WRT DCLKB D_AH LWE LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD
+LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO WRB:O WRT:O DCLKB:I D_AH:I LWE:I
XI42 NET076 LWE me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI40 DICB DICT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI48 NET038 LDIB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI47 LDIB LDIT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI46 WRT NET037 me84a03_INVH LN=0.07U LP=me84a03_LD WN=0.6U WP=0.6U
XI45 WRB NET034 me84a03_INVH LN=0.07U LP=me84a03_LD WN=0.6U WP=0.6U
XI41 DICT DCLKB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.3U
XXDA LDIT DICB DICT DIB me84a03_L2BIO
XI44 NET034 NET076 LDIB me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U
+WP1=0.3U WP2=0.3U
XI43 NET037 NET076 NET038 me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U
+WP1=0.3U WP2=0.3U
XI6 NET51 D_AH me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI7 NET49 NET51 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI8 DIB NET49 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
.ENDS me84a03_WRDRV2_LITE_LC_8

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CMUX_8                                                               *
* LAST TIME SAVED:  MAY 08 15:23:01 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CMUX_8 BB BT RDB RDT WRB WRT PCB
*.PININFO BB:B BT:B RDB:B RDT:B WRB:B WRT:B PCB:I
XMP2 VDD PRCHB BB VDD P12_LP W=0.35U L=me84a03_LD M=1
XMP1 VDD PRCHB BT VDD P12_LP W=0.35U L=me84a03_LD M=1
XMP3 BT PRCHB BB VDD P12_LP W=0.35U L=me84a03_LD M=1
XMP5 BB NET48 RDB VDD P12_LP W=0.3U L=me84a03_LD M=1
XMP4 BT NET48 RDT VDD P12_LP W=0.3U L=me84a03_LD M=1
XMN2 BB PRCHB WRB VSS N12_LP W=0.45U L=0.08U M=1
XMN1 BT PRCHB WRT VSS N12_LP W=0.45U L=0.08U M=1
XI3 PRCHB NET48 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.25U WP=0.25U
XI16 NET48 PCB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
.ENDS me84a03_CMUX_8

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CMUX2_8                                                              *
* LAST TIME SAVED:  MAY 08 15:23:07 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CMUX2_8 BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0
*.PININFO BB1:B BB0:B BT1:B BT0:B RDB:B RDT:B WRB:B WRT:B PCB1:I PCB0:I
XX0 BB0 BT0 RDB RDT WRB WRT PCB0 me84a03_CMUX_8
XXM BB1 BT1 RDB RDT WRB WRT PCB1 me84a03_CMUX_8
.ENDS me84a03_CMUX2_8

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2_LC_8                                                           *
* LAST TIME SAVED:  MAY 08 15:22:57 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2_LC_8 BB0 BB1 BCB BCT BT0 BT1 CCRD DA DCLKB LOG0 LOG1
+LWE0 LWE1 PCB0 PCB1 Q SAEB SWBAWT SWBAWTB TDA LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND
+LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BCB:I BCT:I BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B
*.PININFO LWE0:I LWE1:I PCB0:B PCB1:B Q:O SAEB:I SWBAWT:I SWBAWTB:I TDA:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET039 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDI WRB WRT DCLKB NET29 LWE0 me84a03_WRDRV2_LITE_LC_8
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2_8
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET040 CCRD me84a03_LSA1
DI34 VSS TDA HVTNDIO12_LP AREA=ARD PJ=PRD
DI30 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
XXDO NET29 Q BCB BCT DA LQT SWBAWT SWBAWTB TDA me84a03_DO2_LC
XI36 NET040 SAEB NET039 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2_LC_8

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ND2H                                                                 *
* LAST TIME SAVED:  APR 02 12:25:11 2014                                      *
*******************************************************************************
.SUBCKT me84a03_ND2H Z A B LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
+WN1=me84a03_WND WN2=me84a03_WND WP1=me84a03_WPD WP2=me84a03_WPD
*.PININFO Z:O A:I B:I
XMTP2 VDD B Z VDD PHVT12_LP W=WP2 L=LP2 M=1
XMTP1 VDD A Z VDD PHVT12_LP W=WP1 L=LP1 M=1
XMTN1 Z A N1 VSS NHVT12_LP W=WN1 L=LN1 M=1
XMTN2 N1 B VSS VSS NHVT12_LP W=WN2 L=LN2 M=1
.ENDS me84a03_ND2H

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WRDRV_LITE_LC_8                                                      *
* LAST TIME SAVED:  MAY 08 15:22:57 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WRDRV_LITE_LC_8 WRB WRT DCLKB D_AH LWE WEM_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD
+ LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO WRB:O WRT:O DCLKB:I D_AH:I LWE:I WEM_IN:I
XI1 NET057 WEM_IN me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI3 NET55 NET057 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI4 WEMB NET55 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI6 NET51 D_AH me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI7 NET49 NET51 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI8 DIB NET49 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI15 NET064 LDIB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XXID LDIB LDIT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI16 WRT NET24 me84a03_INVH LN=0.07U LP=me84a03_LD WN=0.6U WP=0.6U
XI17 WRB NET21 me84a03_INVH LN=0.07U LP=me84a03_LD WN=0.6U WP=0.6U
XI40 DICB DICT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI41 DICT DCLKB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.3U
XXWEM LLWE DICB DICT WEMB me84a03_L2BIO
XXDA LDIT DICB DICT DIB me84a03_L2BIO
XI29 NET21 NET076 LDIB me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U WP1=0.3U
+ WP2=0.3U
XI28 NET24 NET076 NET064 me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U
+WP1=0.3U WP2=0.3U
XI22 NET076 LWE LLWE me84a03_ND2H WN1=0.34U WN2=0.34U WP1=0.15U WP2=0.15U
.ENDS me84a03_WRDRV_LITE_LC_8

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_TGH                                                                  *
* LAST TIME SAVED:  APR 02 12:31:02 2014                                      *
*******************************************************************************
.SUBCKT me84a03_TGH A Z CK CKB LN=me84a03_LND LP=me84a03_LPD WN=me84a03_WND WP=me84a03_WPD
*.PININFO A:B Z:B CK:I CKB:I
XMTN A CK Z VSS NHVT12_LP W=WN L=LN M=1
XMTP A CKB Z VDD PHVT12_LP W=WP L=LP M=1
.ENDS me84a03_TGH

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IMX2XORH                                                             *
* LAST TIME SAVED:  MAY 08 15:22:58 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IMX2XORH O A AN B BN
*.PININFO O:O A:I AN:I B:I BN:I
XXTG2 AN O B BN me84a03_TGH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XXTG1 A O BN B me84a03_TGH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
.ENDS me84a03_IMX2XORH

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DO_LC                                                                *
* LAST TIME SAVED:  MAY 08 15:23:08 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DO_LC D_AH Q WEM_AH WEM_AL BCB BCT DA LQT SWBAWT SWBAWTB TDA TWEMA WEMA
+LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO D_AH:O Q:O WEM_AH:O WEM_AL:O BCB:I BCT:I DA:I LQT:I SWBAWT:I SWBAWTB:I TDA:I
*.PININFO TWEMA:I WEMA:I
XI25 NET38 D_AH DA BCB BCT TDA me84a03_BEMXIOH
XI24 WEM_AL WEM_AH WEMA BCB BCT TWEMA me84a03_BEMXIOH
XI33 NET46 D_AH NET38 WEM_AH WEM_AL me84a03_IMX2XORH
XI57 QB NET46 SWBAWT SWBAWTB me84a03_CINVWH WN1=0.2U WN2=0.2U WP1=0.4U WP2=0.4U
XI97 QB LQT SWBAWTB SWBAWT me84a03_CINVWH WN1=0.76U WN2=0.76U WP1=1.0U WP2=1.0U
XI4 Q QB me84a03_INVH LN=0.07U LP=0.07U WN=1.4U WP=2.8U
.ENDS me84a03_DO_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2SW_LC_8                                                         *
* LAST TIME SAVED:  MAY 08 15:23:03 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2SW_LC_8 BB0 BB1 BCB BCT BT0 BT1 CCRD DA DCLKB LOG0 LOG1
+LWE0 LWE1 PCB0 PCB1 Q SAEB SWBAWT SWBAWTB TDA TWEMA WEMA WEMA_AH
+WEMA_AL WEMA_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BCB:I BCT:I BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B
*.PININFO LWE0:I LWE1:I PCB0:B PCB1:B Q:O SAEB:I SWBAWT:I SWBAWTB:I TDA:I TWEMA:I
*.PININFO WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI37 NET073 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDI WRB WRT DCLKB NET36 LWE0 WEMA_IN me84a03_WRDRV_LITE_LC_8
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2_8
XXLSA SQB SQT RDT RDB SAE NET086 CCRD me84a03_LSA1
XXDO NET36 Q WEMA_AH WEMA_AL BCB BCT DA LQT SWBAWT SWBAWTB TDA TWEMA WEMA me84a03_DO_LC
DI30 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI34 VSS TDA HVTNDIO12_LP AREA=ARD PJ=PRD
DI35 VSS TWEMA HVTNDIO12_LP AREA=ARD PJ=PRD
DI29 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XI36 NET086 SAEB NET073 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2SW_LC_8

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WRDRV_LITE_LC_16                                                     *
* LAST TIME SAVED:  MAY 08 15:22:55 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WRDRV_LITE_LC_16 WRB WRT DCLKB D_AH LWE WEM_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND
+LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO WRB:O WRT:O DCLKB:I D_AH:I LWE:I WEM_IN:I
XI1 NET057 WEM_IN me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI3 NET55 NET057 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI4 WEMB NET55 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI6 NET51 D_AH me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI7 NET49 NET51 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI8 DIB NET49 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI15 NET064 LDIB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XXID LDIB LDIT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI16 WRT NET24 me84a03_INVH LN=0.07U LP=me84a03_LD WN=0.88U WP=0.6U
XI17 WRB NET21 me84a03_INVH LN=0.07U LP=me84a03_LD WN=0.88U WP=0.6U
XI40 DICB DICT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI41 DICT DCLKB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.3U
XXWEM LLWE DICB DICT WEMB me84a03_L2BIO
XXDA LDIT DICB DICT DIB me84a03_L2BIO
XI29 NET21 NET076 LDIB me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U WP1=0.3U
+ WP2=0.3U
XI28 NET24 NET076 NET064 me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U
+WP1=0.3U WP2=0.3U
XI22 NET076 LWE LLWE me84a03_ND2H WN1=0.34U WN2=0.34U WP1=0.15U WP2=0.15U
.ENDS me84a03_WRDRV_LITE_LC_16

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CMUX_16                                                              *
* LAST TIME SAVED:  MAY 08 15:23:01 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CMUX_16 BB BT RDB RDT WRB WRT PCB
*.PININFO BB:B BT:B RDB:B RDT:B WRB:B WRT:B PCB:I
XMP2 VDD PRCHB BB VDD P12_LP W=0.4U L=me84a03_LD M=1
XMP1 VDD PRCHB BT VDD P12_LP W=0.4U L=me84a03_LD M=1
XMP3 BT PRCHB BB VDD P12_LP W=0.4U L=me84a03_LD M=1
XMP5 BB NET48 RDB VDD P12_LP W=0.3U L=me84a03_LD M=1
XMP4 BT NET48 RDT VDD P12_LP W=0.3U L=me84a03_LD M=1
XMN2 BB PRCHB WRB VSS N12_LP W=0.63U L=0.08U M=1
XMN1 BT PRCHB WRT VSS N12_LP W=0.63U L=0.08U M=1
XI3 PRCHB NET48 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.3U
XI16 NET48 PCB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
.ENDS me84a03_CMUX_16

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CMUX2_16                                                             *
* LAST TIME SAVED:  MAY 08 15:23:08 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CMUX2_16 BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0
*.PININFO BB1:B BB0:B BT1:B BT0:B RDB:B RDT:B WRB:B WRT:B PCB1:I PCB0:I
XX0 BB0 BT0 RDB RDT WRB WRT PCB0 me84a03_CMUX_16
XXM BB1 BT1 RDB RDT WRB WRT PCB1 me84a03_CMUX_16
.ENDS me84a03_CMUX2_16

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2SW_LC_16                                                        *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2SW_LC_16 BB0 BB1 BCB BCT BT0 BT1 CCRD DA DCLKB LOG0 LOG1
+LWE0 LWE1 PCB0 PCB1 Q SAEB SWBAWT SWBAWTB TDA TWEMA WEMA WEMA_AH
+WEMA_AL WEMA_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BCB:I BCT:I BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B
*.PININFO LWE0:I LWE1:I PCB0:B PCB1:B Q:O SAEB:I SWBAWT:I SWBAWTB:I TDA:I TWEMA:I
*.PININFO WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI37 NET073 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDI WRB WRT DCLKB NET37 LWE0 WEMA_IN me84a03_WRDRV_LITE_LC_16
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2_16
XXLSA SQB SQT RDT RDB SAE NET086 CCRD me84a03_LSA1
XXDO NET37 Q WEMA_AH WEMA_AL BCB BCT DA LQT SWBAWT SWBAWTB TDA TWEMA WEMA me84a03_DO_LC
DI30 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI34 VSS TDA HVTNDIO12_LP AREA=ARD PJ=PRD
DI35 VSS TWEMA HVTNDIO12_LP AREA=ARD PJ=PRD
DI29 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XI36 NET086 SAEB NET073 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2SW_LC_16

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WRDRV2_LITE_LC_16                                                    *
* LAST TIME SAVED:  MAY 08 15:22:54 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WRDRV2_LITE_LC_16 WRB WRT DCLKB D_AH LWE LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD
+LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO WRB:O WRT:O DCLKB:I D_AH:I LWE:I
XXDA LDIT DICB DICT DIB me84a03_L2BIO
XI42 NET076 LWE me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XXID LDIB LDIT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI40 DICB DICT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI16 WRT NET029 me84a03_INVH LN=0.07U LP=me84a03_LD WN=0.88U WP=0.6U
XI17 WRB NET026 me84a03_INVH LN=0.07U LP=me84a03_LD WN=0.88U WP=0.6U
XI41 DICT DCLKB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.3U
XI15 NET038 LDIB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI29 NET026 NET076 LDIB me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U
+WP1=0.3U WP2=0.3U
XI28 NET029 NET076 NET038 me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U
+WP1=0.3U WP2=0.3U
XI6 NET51 D_AH me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI7 NET49 NET51 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI8 DIB NET49 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
.ENDS me84a03_WRDRV2_LITE_LC_16

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2_LC_16                                                          *
* LAST TIME SAVED:  MAY 08 15:22:53 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2_LC_16 BB0 BB1 BCB BCT BT0 BT1 CCRD DA DCLKB LOG0 LOG1
+LWE0 LWE1 PCB0 PCB1 Q SAEB SWBAWT SWBAWTB TDA LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND
+LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BCB:I BCT:I BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B
*.PININFO LWE0:I LWE1:I PCB0:B PCB1:B Q:O SAEB:I SWBAWT:I SWBAWTB:I TDA:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET039 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDI WRB WRT DCLKB NET29 LWE0 me84a03_WRDRV2_LITE_LC_16
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2_16
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET040 CCRD me84a03_LSA1
DI34 VSS TDA HVTNDIO12_LP AREA=ARD PJ=PRD
DI30 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
XXDO NET29 Q BCB BCT DA LQT SWBAWT SWBAWTB TDA me84a03_DO2_LC
XI36 NET040 SAEB NET039 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2_LC_16

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WRDRV_LITE_LC_32                                                     *
* LAST TIME SAVED:  MAY 08 15:23:13 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WRDRV_LITE_LC_32 WRB WRT DCLKB D_AH LWE WEM_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND
+LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO WRB:O WRT:O DCLKB:I D_AH:I LWE:I WEM_IN:I
XI1 NET057 WEM_IN me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI3 NET55 NET057 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI4 WEMB NET55 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI6 NET51 D_AH me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI7 NET49 NET51 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI8 DIB NET49 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI15 NET064 LDIB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XXID LDIB LDIT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI16 WRT NET24 me84a03_INVH LN=0.07U LP=me84a03_LD WN=1.16U WP=0.6U
XI17 WRB NET21 me84a03_INVH LN=0.07U LP=me84a03_LD WN=1.16U WP=0.6U
XI40 DICB DICT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI41 DICT DCLKB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.3U
XXWEM LLWE DICB DICT WEMB me84a03_L2BIO
XXDA LDIT DICB DICT DIB me84a03_L2BIO
XI29 NET21 NET076 LDIB me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U WP1=0.3U
+ WP2=0.3U
XI28 NET24 NET076 NET064 me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U
+WP1=0.3U WP2=0.3U
XI22 NET076 LWE LLWE me84a03_ND2H WN1=0.34U WN2=0.34U WP1=0.15U WP2=0.15U
.ENDS me84a03_WRDRV_LITE_LC_32

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CMUX_32                                                              *
* LAST TIME SAVED:  MAY 08 15:23:01 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CMUX_32 BB BT RDB RDT WRB WRT PCB
*.PININFO BB:B BT:B RDB:B RDT:B WRB:B WRT:B PCB:I
XMP2 VDD PRCHB BB VDD P12_LP W=0.45U L=me84a03_LD M=1
XMP1 VDD PRCHB BT VDD P12_LP W=0.45U L=me84a03_LD M=1
XMP3 BT PRCHB BB VDD P12_LP W=0.45U L=me84a03_LD M=1
XMP5 BB NET48 RDB VDD P12_LP W=0.3U L=me84a03_LD M=1
XMP4 BT NET48 RDT VDD P12_LP W=0.3U L=me84a03_LD M=1
XMN2 BB PRCHB WRB VSS N12_LP W=0.86U L=0.08U M=1
XMN1 BT PRCHB WRT VSS N12_LP W=0.86U L=0.08U M=1
XI3 PRCHB NET48 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.35U
XI16 NET48 PCB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.4U
.ENDS me84a03_CMUX_32

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CMUX2_32                                                             *
* LAST TIME SAVED:  MAY 08 15:22:59 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CMUX2_32 BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0
*.PININFO BB1:B BB0:B BT1:B BT0:B RDB:B RDT:B WRB:B WRT:B PCB1:I PCB0:I
XX0 BB0 BT0 RDB RDT WRB WRT PCB0 me84a03_CMUX_32
XXM BB1 BT1 RDB RDT WRB WRT PCB1 me84a03_CMUX_32
.ENDS me84a03_CMUX2_32

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2SW_LC_32                                                        *
* LAST TIME SAVED:  MAY 08 15:22:56 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2SW_LC_32 BB0 BB1 BCB BCT BT0 BT1 CCRD DA DCLKB LOG0 LOG1
+LWE0 LWE1 PCB0 PCB1 Q SAEB SWBAWT SWBAWTB TDA TWEMA WEMA WEMA_AH
+WEMA_AL WEMA_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BCB:I BCT:I BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B
*.PININFO LWE0:I LWE1:I PCB0:B PCB1:B Q:O SAEB:I SWBAWT:I SWBAWTB:I TDA:I TWEMA:I
*.PININFO WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI37 NET073 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDI WRB WRT DCLKB NET37 LWE0 WEMA_IN me84a03_WRDRV_LITE_LC_32
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2_32
XXLSA SQB SQT RDT RDB SAE NET086 CCRD me84a03_LSA1
XXDO NET37 Q WEMA_AH WEMA_AL BCB BCT DA LQT SWBAWT SWBAWTB TDA TWEMA WEMA me84a03_DO_LC
DI30 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI34 VSS TDA HVTNDIO12_LP AREA=ARD PJ=PRD
DI35 VSS TWEMA HVTNDIO12_LP AREA=ARD PJ=PRD
DI29 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XI36 NET086 SAEB NET073 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2SW_LC_32

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WRDRV2_LITE_LC_32                                                    *
* LAST TIME SAVED:  MAY 08 15:23:09 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WRDRV2_LITE_LC_32 WRB WRT DCLKB D_AH LWE LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD
+LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO WRB:O WRT:O DCLKB:I D_AH:I LWE:I
XXDA LDIT DICB DICT DIB me84a03_L2BIO
XI42 NET076 LWE me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XXID LDIB LDIT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI40 DICB DICT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI16 WRT NET029 me84a03_INVH LN=0.07U LP=me84a03_LD WN=1.16U WP=0.6U
XI17 WRB NET026 me84a03_INVH LN=0.07U LP=me84a03_LD WN=1.16U WP=0.6U
XI41 DICT DCLKB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.3U
XI15 NET038 LDIB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI29 NET026 NET076 LDIB me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U
+WP1=0.3U WP2=0.3U
XI28 NET029 NET076 NET038 me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U
+WP1=0.3U WP2=0.3U
XI6 NET51 D_AH me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI7 NET49 NET51 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI8 DIB NET49 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
.ENDS me84a03_WRDRV2_LITE_LC_32

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2_LC_32                                                          *
* LAST TIME SAVED:  MAY 08 15:22:50 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2_LC_32 BB0 BB1 BCB BCT BT0 BT1 CCRD DA DCLKB LOG0 LOG1
+LWE0 LWE1 PCB0 PCB1 Q SAEB SWBAWT SWBAWTB TDA LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND
+LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BCB:I BCT:I BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B
*.PININFO LWE0:I LWE1:I PCB0:B PCB1:B Q:O SAEB:I SWBAWT:I SWBAWTB:I TDA:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET039 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDI WRB WRT DCLKB NET29 LWE0 me84a03_WRDRV2_LITE_LC_32
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2_32
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET040 CCRD me84a03_LSA1
DI34 VSS TDA HVTNDIO12_LP AREA=ARD PJ=PRD
DI30 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
XXDO NET29 Q BCB BCT DA LQT SWBAWT SWBAWTB TDA me84a03_DO2_LC
XI36 NET040 SAEB NET039 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2_LC_32

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DO_LITE_LC                                                           *
* LAST TIME SAVED:  MAY 08 15:23:07 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DO_LITE_LC D_AH Q WEM_AH WEM_AL D LQT WEM
*.PININFO D_AH:O Q:O WEM_AH:O WEM_AL:O D:I LQT:I WEM:I
XI38 WEM_AL WEM me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
XI36 D_AH NET18 me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
XI39 WEM_AH WEM_AL me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
XI30 NET21 LQT me84a03_INVH LN=0.07U LP=0.07U WN=0.44U WP=.88U
XI29 Q NET21 me84a03_INVH LN=0.07U LP=.07U WN=1.4U WP=2.8U
XI37 NET18 D me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
.ENDS me84a03_DO_LITE_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2SW_LITE_LC_8                                                    *
* LAST TIME SAVED:  MAY 08 15:23:02 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2SW_LITE_LC_8 BB0 BB1 BT0 BT1 CCRD DA DCLKB LOG0 LOG1 LWE0
+ LWE1 PCB0 PCB1 Q SAEB WEMA WEMA_AH WEMA_AL WEMA_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND
+ LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE0:I
*.PININFO LWE1:I PCB0:B PCB1:B Q:O SAEB:I WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET028 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDI WRB WRT DCLKB NET24 LWE0 WEMA_IN me84a03_WRDRV_LITE_LC_8
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2_8
DI29 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI30 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXLSA SQB SQT RDT RDB SAE NET029 CCRD me84a03_LSA1
XXDO NET24 Q WEMA_AH WEMA_AL DA LQT WEMA me84a03_DO_LITE_LC
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XI36 NET029 SAEB NET028 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2SW_LITE_LC_8

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2SW_LITE_LC_16                                                   *
* LAST TIME SAVED:  MAY 08 15:23:03 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2SW_LITE_LC_16 BB0 BB1 BT0 BT1 CCRD DA DCLKB LOG0 LOG1
+LWE0 LWE1 PCB0 PCB1 Q SAEB WEMA WEMA_AH WEMA_AL WEMA_IN LN=me84a03_LND LN1=me84a03_LND
+LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE0:I
*.PININFO LWE1:I PCB0:B PCB1:B Q:O SAEB:I WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET028 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDI WRB WRT DCLKB NET24 LWE0 WEMA_IN me84a03_WRDRV_LITE_LC_16
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2_16
DI29 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI30 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXLSA SQB SQT RDT RDB SAE NET029 CCRD me84a03_LSA1
XXDO NET24 Q WEMA_AH WEMA_AL DA LQT WEMA me84a03_DO_LITE_LC
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XI36 NET029 SAEB NET028 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2SW_LITE_LC_16

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2SW_LITE_LC_32                                                   *
* LAST TIME SAVED:  MAY 08 15:23:06 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2SW_LITE_LC_32 BB0 BB1 BT0 BT1 CCRD DA DCLKB LOG0 LOG1
+LWE0 LWE1 PCB0 PCB1 Q SAEB WEMA WEMA_AH WEMA_AL WEMA_IN LN=me84a03_LND LN1=me84a03_LND
+LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE0:I
*.PININFO LWE1:I PCB0:B PCB1:B Q:O SAEB:I WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET028 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDI WRB WRT DCLKB NET25 LWE0 WEMA_IN me84a03_WRDRV_LITE_LC_32
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2_32
DI29 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI30 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXLSA SQB SQT RDT RDB SAE NET029 CCRD me84a03_LSA1
XXDO NET25 Q WEMA_AH WEMA_AL DA LQT WEMA me84a03_DO_LITE_LC
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XI36 NET029 SAEB NET028 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2SW_LITE_LC_32

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CMUX4_8                                                              *
* LAST TIME SAVED:  MAY 08 15:22:51 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CMUX4_8 BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 RDB RDT WRB WRT
+PCB3 PCB2 PCB1 PCB0
*.PININFO BB3:B BB2:B BB1:B BB0:B BT3:B BT2:B BT1:B BT0:B RDB:B RDT:B
*.PININFO WRB:B WRT:B PCB3:I PCB2:I PCB1:I PCB0:I
XX0 BB0 BT0 RDB RDT WRB WRT PCB0 me84a03_CMUX_8
XX1 BB1 BT1 RDB RDT WRB WRT PCB1 me84a03_CMUX_8
XX2 BB2 BT2 RDB RDT WRB WRT PCB2 me84a03_CMUX_8
XXM BB3 BT3 RDB RDT WRB WRT PCB3 me84a03_CMUX_8
.ENDS me84a03_CMUX4_8

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM4_LC_8                                                           *
* LAST TIME SAVED:  MAY 08 15:23:06 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM4_LC_8 BB0 BB1 BB2 BB3 BCB BCT BT0 BT1 BT2 BT3 CCRD
+DA DCLKB LOG0 LOG1 LWE PCB0 PCB1 PCB2 PCB3 Q SAEB SWBAWT SWBAWTB TDA
+TWEMA WEMA WEMA_AH WEMA_AL WEMA_IN LN=me84a03_LND LN1=me84a03_LND
+LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BB2:B BB3:B BCB:I BCT:I BT0:B BT1:B BT2:B BT3:B
*.PININFO CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE:I PCB0:B PCB1:B PCB2:B PCB3:B Q:O
*.PININFO SAEB:I SWBAWT:I SWBAWTB:I TDA:I TWEMA:I WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET057 LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDI WRB WRT DCLKB NET42 LWE WEMA_IN me84a03_WRDRV_LITE_LC_8
XXMX BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 RDB RDT WRB WRT PCB3
+PCB2 PCB1 PCB0 me84a03_CMUX4_8
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXDO NET42 Q WEMA_AH WEMA_AL BCB BCT DA LQT SWBAWT SWBAWTB TDA TWEMA WEMA me84a03_DO_LC
DI30 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI34 VSS TDA HVTNDIO12_LP AREA=ARD PJ=PRD
DI35 VSS TWEMA HVTNDIO12_LP AREA=ARD PJ=PRD
DI29 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXLSA SQB SQT RDT RDB SAE NET060 CCRD me84a03_LSA1
XI36 NET060 SAEB NET057 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM4_LC_8

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CMUX4_16                                                             *
* LAST TIME SAVED:  MAY 08 15:22:53 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CMUX4_16 BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 RDB RDT WRB WRT
+ PCB3 PCB2 PCB1 PCB0
*.PININFO BB3:B BB2:B BB1:B BB0:B BT3:B BT2:B BT1:B BT0:B RDB:B RDT:B
*.PININFO WRB:B WRT:B PCB3:I PCB2:I PCB1:I PCB0:I
XX0 BB0 BT0 RDB RDT WRB WRT PCB0 me84a03_CMUX_16
XX1 BB1 BT1 RDB RDT WRB WRT PCB1 me84a03_CMUX_16
XX2 BB2 BT2 RDB RDT WRB WRT PCB2 me84a03_CMUX_16
XXM BB3 BT3 RDB RDT WRB WRT PCB3 me84a03_CMUX_16
.ENDS me84a03_CMUX4_16

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM4_LC_16                                                          *
* LAST TIME SAVED:  MAY 08 15:23:02 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM4_LC_16 BB0 BB1 BB2 BB3 BCB BCT BT0 BT1 BT2 BT3 CCRD
+ DA DCLKB LOG0 LOG1 LWE PCB0 PCB1 PCB2 PCB3 Q SAEB SWBAWT SWBAWTB TDA
+TWEMA WEMA WEMA_AH WEMA_AL WEMA_IN LN=me84a03_LND LN1=me84a03_LND
+LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BB2:B BB3:B BCB:I BCT:I BT0:B BT1:B BT2:B BT3:B
*.PININFO CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE:I PCB0:B PCB1:B PCB2:B PCB3:B Q:O
*.PININFO SAEB:I SWBAWT:I SWBAWTB:I TDA:I TWEMA:I WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET057 LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXMX BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 RDB RDT WRB WRT PCB3
+PCB2 PCB1 PCB0 me84a03_CMUX4_16
XXDI WRB WRT DCLKB NET42 LWE WEMA_IN me84a03_WRDRV_LITE_LC_16
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXDO NET42 Q WEMA_AH WEMA_AL BCB BCT DA LQT SWBAWT SWBAWTB TDA TWEMA WEMA me84a03_DO_LC
DI30 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI34 VSS TDA HVTNDIO12_LP AREA=ARD PJ=PRD
DI35 VSS TWEMA HVTNDIO12_LP AREA=ARD PJ=PRD
DI29 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXLSA SQB SQT RDT RDB SAE NET060 CCRD me84a03_LSA1
XI36 NET060 SAEB NET057 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM4_LC_16

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CMUX4_32                                                             *
* LAST TIME SAVED:  MAY 08 15:23:08 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CMUX4_32 BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 RDB RDT WRB WRT
+ PCB3 PCB2 PCB1 PCB0
*.PININFO BB3:B BB2:B BB1:B BB0:B BT3:B BT2:B BT1:B BT0:B RDB:B RDT:B
*.PININFO WRB:B WRT:B PCB3:I PCB2:I PCB1:I PCB0:I
XX0 BB0 BT0 RDB RDT WRB WRT PCB0 me84a03_CMUX_32
XX1 BB1 BT1 RDB RDT WRB WRT PCB1 me84a03_CMUX_32
XX2 BB2 BT2 RDB RDT WRB WRT PCB2 me84a03_CMUX_32
XXM BB3 BT3 RDB RDT WRB WRT PCB3 me84a03_CMUX_32
.ENDS me84a03_CMUX4_32

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM4_LC_32                                                          *
* LAST TIME SAVED:  MAY 08 15:23:00 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM4_LC_32 BB0 BB1 BB2 BB3 BCB BCT BT0 BT1 BT2 BT3 CCRD
+ DA DCLKB LOG0 LOG1 LWE PCB0 PCB1 PCB2 PCB3 Q SAEB SWBAWT SWBAWTB TDA
+TWEMA WEMA WEMA_AH WEMA_AL WEMA_IN LN=me84a03_LND LN1=me84a03_LND
+LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BB2:B BB3:B BCB:I BCT:I BT0:B BT1:B BT2:B BT3:B
*.PININFO CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE:I PCB0:B PCB1:B PCB2:B PCB3:B Q:O
*.PININFO SAEB:I SWBAWT:I SWBAWTB:I TDA:I TWEMA:I WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET057 LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXMX BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 RDB RDT WRB WRT PCB3
+PCB2 PCB1 PCB0 me84a03_CMUX4_32
XXDI WRB WRT DCLKB NET41 LWE WEMA_IN me84a03_WRDRV_LITE_LC_32
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXDO NET41 Q WEMA_AH WEMA_AL BCB BCT DA LQT SWBAWT SWBAWTB TDA TWEMA WEMA me84a03_DO_LC
DI30 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI34 VSS TDA HVTNDIO12_LP AREA=ARD PJ=PRD
DI35 VSS TWEMA HVTNDIO12_LP AREA=ARD PJ=PRD
DI29 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXLSA SQB SQT RDT RDB SAE NET060 CCRD me84a03_LSA1
XI36 NET060 SAEB NET057 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM4_LC_32

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_LOG                                                                  *
* LAST TIME SAVED:  MAY 08 15:22:58 2014                                      *
*******************************************************************************
.SUBCKT me84a03_LOG LOG0
*.PININFO LOG0:B
XMI255 VSS ALWAYS1 ALWAYS0 VSS N12_LP W=0.6U L=me84a03_LD M=1
XMI248 VSS ZERO ALWAYS0 VSS N12_LP W=0.6U L=me84a03_LD M=1
XMI266 VSS ALWAYS1 LOG0 VSS N12_LP W=9.0U L=me84a03_LD M=1
XI284 ZERO ALWAYS1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.6U
XI244 ALWAYS1 ALWAYS0 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.6U
.ENDS me84a03_LOG

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RM4TO1_LC                                                            *
* LAST TIME SAVED:  MAY 08 15:23:05 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RM4TO1_LC Z ZB A B C D SA SB0 SB1 SC0 SC1 SD0 SD1
*.PININFO Z:O ZB:O A:I B:I C:I D:I SA:I SB0:I SB1:I SC0:I SC1:I SD0:I SD1:I
XMI1 A SA NET33 VSS NHVT12_LP W=0.2U L=me84a03_LND M=1
XI3 Z ZB me84a03_INVH WN=0.2U WP=0.4U
XI2 ZB NET33 me84a03_INVH WN=0.2U WP=0.4U
XIQ5 C NET33 SC1 SC0 me84a03_TGH WN=0.2U WP=0.2U
XIQ6 D NET33 SD1 SD0 me84a03_TGH WN=0.2U WP=0.2U
XIQ4 B NET33 SB1 SB0 me84a03_TGH WN=0.2U WP=0.2U
.ENDS me84a03_RM4TO1_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RM2TO4_LC                                                            *
* LAST TIME SAVED:  MAY 08 15:23:09 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RM2TO4_LC RMENB SEL001 SEL000 SEL011 SEL010 SEL101 SEL100
+SEL111 SEL110 PRM04 PRM03 PRM02 PRM01 PRM00 PRM14 PRM13
+PRM12 PRM11 PRM10 RM1 RM0 RMEN RMENI1 RMENI0 LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD
+ LP2=me84a03_LPD
*.PININFO RMENB:O SEL001:O SEL000:O SEL011:O SEL010:O SEL101:O SEL100:O
*.PININFO SEL111:O SEL110:O PRM04:B PRM03:B PRM02:B PRM01:B PRM00:B
*.PININFO PRM14:B PRM13:B PRM12:B PRM11:B PRM10:B RM1:I RM0:I RMEN:I
*.PININFO RMENI1:I RMENI0:I
XI33 RMENB RMEN me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI25 A PRM04 me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI989 SEL111 SEL110 me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI963 SEL001 SEL000 me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI948 SEL101 SEL100 me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI951 SEL011 SEL010 me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI43 B PRM14 me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XMI19 PRM02 RMENI0 PRM03 VDD PHVT12_LP W=0.2U L=me84a03_LPD M=1
XMI18 VDD RM0 PRM03 VDD PHVT12_LP W=0.2U L=me84a03_LPD M=1
XMI40 PRM12 RMENI1 PRM13 VDD PHVT12_LP W=0.2U L=me84a03_LPD M=1
XMI39 VDD RM1 PRM13 VDD PHVT12_LP W=0.2U L=me84a03_LPD M=1
XMI21 PRM01 RMENI0 PRM00 VSS NHVT12_LP W=0.2U L=me84a03_LND M=1
XMI20 PRM01 RM0 VSS VSS NHVT12_LP W=0.2U L=me84a03_LND M=1
XMI42 PRM11 RM1 VSS VSS NHVT12_LP W=0.2U L=me84a03_LND M=1
XMI41 PRM11 RMENI1 PRM10 VSS NHVT12_LP W=0.2U L=me84a03_LND M=1
XI4 SEL110 B A me84a03_ND2H WN1=0.2U WN2=0.2U WP1=0.2U WP2=0.2U
XI3 SEL100 B PRM04 me84a03_ND2H WN1=0.2U WN2=0.2U WP1=0.2U WP2=0.2U
XI2 SEL010 PRM14 A me84a03_ND2H WN1=0.2U WN2=0.2U WP1=0.2U WP2=0.2U
XI1 SEL000 PRM14 PRM04 me84a03_ND2H WN1=0.2U WN2=0.2U WP1=0.2U WP2=0.2U
.ENDS me84a03_RM2TO4_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ND3H                                                                 *
* LAST TIME SAVED:  APR 29 16:27:05 2014                                      *
*******************************************************************************
.SUBCKT me84a03_ND3H Z A B C LN1=me84a03_LND LN2=me84a03_LND LN3=me84a03_LND LP1=me84a03_LPD
+LP2=me84a03_LPD LP3=me84a03_LPD WN1=me84a03_WND
+WN2=me84a03_WND WN3=me84a03_WND WP1=me84a03_WPD WP2=me84a03_WPD WP3=me84a03_WPD
*.PININFO Z:O A:I B:I C:I
XMTP2 VDD B Z VDD PHVT12_LP W=WP2 L=LP2 M=1
XMTP1 VDD A Z VDD PHVT12_LP W=WP1 L=LP1 M=1
XMTP3 VDD C Z VDD PHVT12_LP W=WP3 L=LP3 M=1
XMTN2 NET42 B N2 VSS NHVT12_LP W=WN2 L=LN2 M=1
XMTN3 N2 C VSS VSS NHVT12_LP W=WN3 L=LN3 M=1
XMTN1 Z A NET42 VSS NHVT12_LP W=WN1 L=LN1 M=1
.ENDS me84a03_ND3H

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RMMX_LC                                                              *
* LAST TIME SAVED:  MAY 08 15:22:57 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RMMX_LC ACUTRK RMENB RW_RBL Z0B Z2 Z1 Z0 PRM04 PRM03 PRM02
+PRM01 PRM00 PRM14 PRM13 PRM12 PRM11 PRM10 RMDEF2 RMDEF1
+RMDEF0 RMEN RMENI1 RMENI0 RMEXT3 RMEXT2 RMEXT1 RMEXT0 RMFAST2
+RMFAST1 RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 LN1=me84a03_LND LN2=me84a03_LND LN3=me84a03_LND LP1=me84a03_LPD
+ LP2=me84a03_LPD LP3=me84a03_LPD
*.PININFO ACUTRK:O RMENB:O RW_RBL:O Z0B:O Z2:O Z1:O Z0:O PRM04:B PRM03:B
*.PININFO PRM02:B PRM01:B PRM00:B PRM14:B PRM13:B PRM12:B PRM11:B PRM10:B
*.PININFO RMDEF2:I RMDEF1:I RMDEF0:I RMEN:I RMENI1:I RMENI0:I RMEXT3:I
*.PININFO RMEXT2:I RMEXT1:I RMEXT0:I RMFAST2:I RMFAST1:I RMFAST0:I RMSLOW2:I
*.PININFO RMSLOW1:I RMSLOW0:I
XI3 Z1 NET080 VSS RMSLOW1 RMDEF1 RMFAST1 SA1 SB0 SB1 SC0 SC1
+SD0 SD1 me84a03_RM4TO1_LC
XI4 Z2 NET070 VSS RMSLOW2 RMDEF2 RMFAST2 SA1 SB0 SB1 SC0 SC1
+SD0 SD1 me84a03_RM4TO1_LC
XI2 Z0 Z0B VSS RMSLOW0 RMDEF0 RMFAST0 SA1 SB0 SB1 SC0 SC1
+SD0 SD1 me84a03_RM4TO1_LC
DI30 VSS RMEXT3 NDIO12_LP AREA=ARD PJ=PRD
DI27 VSS RMEXT2 NDIO12_LP AREA=ARD PJ=PRD
DI37 VSS RMEXT0 NDIO12_LP AREA=ARD PJ=PRD
DI26 VSS RMEXT1 NDIO12_LP AREA=ARD PJ=PRD
DI31 VSS RMEN NDIO12_LP AREA=ARD PJ=PRD
XI1 RMENB SA1 SA0 SB1 SB0 SC1 SC0 SD1 SD0 PRM04 PRM03
+PRM02 PRM01 PRM00 PRM14 PRM13 PRM12 PRM11 PRM10 RMEXT1
+RMEXT0 RMEN RMENI1 RMENI0 me84a03_RM2TO4_LC
XI43 ACUTRK SC0 SD0 me84a03_ND2H WN1=0.4U WN2=0.4U WP1=0.4U WP2=0.4U
XI20 NET55 RMEXT2 RMEN me84a03_ND2H WN1=0.2U WN2=0.2U WP1=0.2U WP2=0.2U
XI40 RW_RBL SB0 SA0 NET55 me84a03_ND3H WN1=0.2U WN2=0.2U WN3=0.2U WP1=0.2U WP2=0.2U
+WP3=0.2U
.ENDS me84a03_RMMX_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_BEMX                                                                 *
* LAST TIME SAVED:  MAY 08 15:23:08 2014                                      *
*******************************************************************************
.SUBCKT me84a03_BEMX QB QT A BCB BCT TA
*.PININFO QB:O QT:O A:I BCB:I BCT:I TA:I
XMI151 VDD BCB PT VDD P12_LP W=1.0U L=me84a03_LD M=1
XMI152 PT TA QB VDD P12_LP W=1.0U L=me84a03_LD M=1
XMI132 VDD BCT PA VDD P12_LP W=1.0U L=me84a03_LD M=1
XMI133 PA A QB VDD P12_LP W=1.0U L=me84a03_LD M=1
DI2 VSS TA NDIO12_LP AREA=ARD PJ=PRD
DI0 VSS A NDIO12_LP AREA=ARD PJ=PRD
XMI153 NT TA QB VSS N12_LP W=0.5U L=me84a03_LD M=1
XMI154 VSS BCT NT VSS N12_LP W=0.5U L=me84a03_LD M=1
XMI134 NA A QB VSS N12_LP W=0.5U L=me84a03_LD M=1
XMI135 VSS BCB NA VSS N12_LP W=0.5U L=me84a03_LD M=1
XI137 QT QB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.44U WP=0.88U
.ENDS me84a03_BEMX

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IMX2XOR                                                              *
* LAST TIME SAVED:  MAY 08 15:23:07 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IMX2XOR O A AN B BN LN=me84a03_LND LP=me84a03_LPD
*.PININFO O:O A:I AN:I B:I BN:I
XXTG2 AN O B BN me84a03_TG LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XXTG1 A O BN B me84a03_TG LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
.ENDS me84a03_IMX2XOR

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_XOR2B                                                                *
* LAST TIME SAVED:  APR 23 15:28:46 2014                                      *
*******************************************************************************
.SUBCKT me84a03_XOR2B Z A B LN2=me84a03_LND LP2=me84a03_LPD WN1=me84a03_WND WN2=me84a03_WND WP1=me84a03_WPD WP2=me84a03_WPD
*.PININFO Z:O A:I B:I
XI0 NET28 B me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=WN1 WP=WP1
XI3 Z ZB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=WN1 WP=WP1
XMTN2 ZB A B VSS N12_LP W=WN2 L=LN2 M=1
XMI1 A B ZB VSS N12_LP W=WN2 L=LN2 M=1
XMTP2 A NET28 ZB VDD P12_LP W=WP2 L=LP2 M=1
XMI2 ZB A NET28 VDD P12_LP W=WP2 L=LP2 M=1
.ENDS me84a03_XOR2B

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_BEMX4                                                                *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_BEMX4 OUTXOR QN3 QN2 QN1 QN0 QT3 QT2 QT1 QT0 BCB BCT
+IN3 IN2 IN1 IN0 TIN3 TIN2 TIN1 TIN0 LN=me84a03_LND LP=me84a03_LPD
*.PININFO OUTXOR:O QN3:O QN2:O QN1:O QN0:O QT3:O QT2:O QT1:O QT0:O BCB:I
*.PININFO BCT:I IN3:I IN2:I IN1:I IN0:I TIN3:I TIN2:I TIN1:I TIN0:I
XX2XOR NET31 QT2 QN2 QT3 QN3 me84a03_IMX2XOR
XX1XOR NET26 QT0 QN0 QT1 QN1 me84a03_IMX2XOR
XI832 QN1 QT1 IN1 BCB BCT TIN1 me84a03_BEMX
XI838 QN2 QT2 IN2 BCB BCT TIN2 me84a03_BEMX
XI8 QN3 QT3 IN3 BCB BCT TIN3 me84a03_BEMX
XI1 QN0 QT0 IN0 BCB BCT TIN0 me84a03_BEMX
XX3XOR OUTXOR NET26 NET31 me84a03_XOR2B LN2=me84a03_LD LP2=me84a03_LD WN1=0.25U WN2=0.25U WP1=0.25U WP2=0.25U
.ENDS me84a03_BEMX4

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_BEMX9                                                                *
* LAST TIME SAVED:  MAY 08 15:22:50 2014                                      *
*******************************************************************************
.SUBCKT me84a03_BEMX9 OUTXOR QN8 QN7 QN6 QN5 QN4 QN3 QN2 QN1 QN0 QT8
+ QT7 QT6 QT5 QT4 QT3 QT2 QT1 QT0 BCB BCT IN8 IN7 IN6
+IN5 IN4 IN3 IN2 IN1 IN0 TIN8 TIN7 TIN6 TIN5 TIN4 TIN3
+TIN2 TIN1 TIN0 LN=me84a03_LND LP=me84a03_LPD
*.PININFO OUTXOR:O QN8:O QN7:O QN6:O QN5:O QN4:O QN3:O QN2:O QN1:O QN0:O
*.PININFO QT8:O QT7:O QT6:O QT5:O QT4:O QT3:O QT2:O QT1:O QT0:O BCB:I
*.PININFO BCT:I IN8:I IN7:I IN6:I IN5:I IN4:I IN3:I IN2:I IN1:I IN0:I
*.PININFO TIN8:I TIN7:I TIN6:I TIN5:I TIN4:I TIN3:I TIN2:I TIN1:I TIN0:I
XI838 QN8 QT8 IN8 BCB BCT TIN8 me84a03_BEMX
XI12 X1 QN7 QN6 QN5 QN4 QT7 QT6 QT5 QT4 BCB BCT IN7 IN6
+IN5 IN4 TIN7 TIN6 TIN5 TIN4 me84a03_BEMX4
XI11 X0 QN3 QN2 QN1 QN0 QT3 QT2 QT1 QT0 BCB BCT IN3 IN2
+IN1 IN0 TIN3 TIN2 TIN1 TIN0 me84a03_BEMX4
XI14 X2 X0 X1 me84a03_XOR2B LN2=me84a03_LD LP2=me84a03_LD WN1=0.25U WN2=0.25U WP1=0.25U WP2=0.25U
XI7 OUTXOR X2 QT8 me84a03_XOR2B LN2=me84a03_LD LP2=me84a03_LD WN1=0.25U WN2=0.25U WP1=0.25U WP2=0.25U
.ENDS me84a03_BEMX9

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ADRMUX                                                               *
* LAST TIME SAVED:  MAY 08 15:23:06 2014                                      *
*******************************************************************************
.SUBCKT me84a03_ADRMUX OUTXOR QXA6 QXA5 QXA4 QXA3 QXA2 QXA1 QXA0 QYA1
+QYA0 BCB BCT TXA6 TXA5 TXA4 TXA3 TXA2 TXA1 TXA0 TYA1 TYA0
+XA6 XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0 LN=me84a03_LND LP=me84a03_LPD
*.PININFO OUTXOR:O QXA6:O QXA5:O QXA4:O QXA3:O QXA2:O QXA1:O QXA0:O QYA1:O
*.PININFO QYA0:O BCB:I BCT:I TXA6:I TXA5:I TXA4:I TXA3:I TXA2:I TXA1:I
*.PININFO TXA0:I TYA1:I TYA0:I XA6:I XA5:I XA4:I XA3:I XA2:I XA1:I
*.PININFO XA0:I YA1:I YA0:I
XXBMX OUTXOR QN8 QN7 QN6 QN5 QN4 QN3 QN2 QN1 QN0 QXA6 QXA5
+QXA4 QXA3 QXA2 QXA1 QXA0 QYA1 QYA0 BCB BCT XA6 XA5 XA4
+XA3 XA2 XA1 XA0 YA1 YA0 TXA6 TXA5 TXA4 TXA3 TXA2 TXA1
+TXA0 TYA1 TYA0 me84a03_BEMX9
.ENDS me84a03_ADRMUX

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ND4                                                                  *
* LAST TIME SAVED:  MAY 07 12:39:32 2013                                      *
*******************************************************************************
.SUBCKT me84a03_ND4 Z A B C D LN1=me84a03_LND LN2=me84a03_LND LN3=me84a03_LND LN4=me84a03_LND
+LP1=me84a03_LPD LP2=me84a03_LPD LP3=me84a03_LPD
+LP4=me84a03_LPD WN1=me84a03_WND WN2=me84a03_WND WN3=me84a03_WND WN4=me84a03_WND
+WP1=me84a03_WPD WP2=me84a03_WPD WP3=me84a03_WPD WP4=me84a03_WPD
*.PININFO Z:O A:I B:I C:I D:I
XMNA1 Z A NET19 VSS N12_LP W=WN1 L=LN1 M=1
XMNA4 NET028 D VSS VSS N12_LP W=WN4 L=LN4 M=1
XMNA2 NET19 B NET022 VSS N12_LP W=WN2 L=LN2 M=1
XMNA3 NET022 C NET028 VSS N12_LP W=WN3 L=LN3 M=1
XMPA1 VDD A Z VDD P12_LP W=WP1 L=LP1 M=1
XMPA4 VDD D Z VDD P12_LP W=WP4 L=LP4 M=1
XMPA2 VDD B Z VDD P12_LP W=WP2 L=LP2 M=1
XMPA3 VDD C Z VDD P12_LP W=WP3 L=LP3 M=1
.ENDS me84a03_ND4

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DEC4TO1B_LC                                                          *
* LAST TIME SAVED:  MAY 08 15:22:59 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DEC4TO1B_LC QB D0 D1 D2 D3
*.PININFO QB:O D0:I D1:I D2:I D3:I
XI94 QT DD me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.28U WP=0.56U
XI0 QB QT me84a03_INV LN=0.07U LP=0.07U WN=1.62U WP=3.24U
XI63 DD D3 D2 D1 D0 me84a03_ND4 LN1=me84a03_LD LN2=me84a03_LD LN3=me84a03_LND LN4=me84a03_LND
+LP1=me84a03_LD LP2=me84a03_LD LP3=me84a03_LPD LP4=me84a03_LPD
+ WN1=0.3U WN2=0.3U WN3=0.3U WN4=0.3U WP1=0.15U WP2=0.15U WP3=0.15U WP4=0.15U
.ENDS me84a03_DEC4TO1B_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ADRLAT_LC                                                            *
* LAST TIME SAVED:  MAY 08 15:22:51 2014                                      *
*******************************************************************************
.SUBCKT me84a03_ADRLAT_LC QB QT A CB CT LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO QB:O QT:O A:I CB:I CT:I
XMI132 VDD A PA VDD P12_LP W=2U L=me84a03_LD M=1
XMI4 PA CT QB VDD P12_LP W=2U L=me84a03_LD M=1
XI1 QB QT CT CB me84a03_CINV LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U WP1=0.15U
+WP2=0.15U
XMI134 NA CB QB VSS N12_LP W=1U L=me84a03_LD M=1
XMI3 VSS A NA VSS N12_LP W=1U L=me84a03_LD M=1
XI137 QT QB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
.ENDS me84a03_ADRLAT_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_PR4B_LC                                                              *
* LAST TIME SAVED:  MAY 08 15:22:54 2014                                      *
*******************************************************************************
.SUBCKT me84a03_PR4B_LC QB3 QB2 QB1 QB0 A1 A0 CB CT LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD
+LP2=me84a03_LPD
*.PININFO QB3:O QB2:O QB1:O QB0:O A1:I A0:I CB:I CT:I
XI131 QB3 LA0QT LA0QT LA1QT LA1QT me84a03_DEC4TO1B_LC
XI129 QB1 LA0QT LA0QT LA1QB LA1QB me84a03_DEC4TO1B_LC
XI130 QB2 LA0QB LA0QB LA1QT LA1QT me84a03_DEC4TO1B_LC
XI307 QB0 LA0QB LA0QB LA1QB LA1QB me84a03_DEC4TO1B_LC
XI168 LA1QB LA1QT A1 CB CT me84a03_ADRLAT_LC
XI165 LA0QB LA0QT A0 CB CT me84a03_ADRLAT_LC
.ENDS me84a03_PR4B_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ND3                                                                  *
* LAST TIME SAVED:  MAY 07 12:39:32 2013                                      *
*******************************************************************************
.SUBCKT me84a03_ND3 Z A B C LN1=me84a03_LND LN2=me84a03_LND LN3=me84a03_LND
+LP1=me84a03_LPD LP2=me84a03_LPD LP3=me84a03_LPD WN1=me84a03_WND WN2=me84a03_WND
+ WN3=me84a03_WND WP1=me84a03_WPD WP2=me84a03_WPD WP3=me84a03_WPD
*.PININFO Z:O A:I B:I C:I
XMPA1 VDD A Z VDD P12_LP W=WP1 L=LP1 M=1
XMPA3 VDD C Z VDD P12_LP W=WP3 L=LP3 M=1
XMPA2 VDD B Z VDD P12_LP W=WP2 L=LP2 M=1
XMNA1 Z A NET19 VSS N12_LP W=WN1 L=LN1 M=1
XMNA2 NET19 B NET019 VSS N12_LP W=WN2 L=LN2 M=1
XMNA3 NET019 C VSS VSS N12_LP W=WN3 L=LN3 M=1
.ENDS me84a03_ND3

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DEC3TO1B_LC                                                          *
* LAST TIME SAVED:  MAY 08 15:22:58 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DEC3TO1B_LC QB D0 D1 D2
*.PININFO QB:O D0:I D1:I D2:I
XI523 QT DD me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.6U
XXQB QB QT me84a03_INV LN=.07U LP=.07U WN=1.28U WP=2.56U
XI63 DD D2 D1 D0 me84a03_ND3 LN1=me84a03_LD LN2=me84a03_LD LN3=me84a03_LND
+LP1=me84a03_LD LP2=me84a03_LD LP3=me84a03_LPD WN1=0.15U WN2=0.15U
+ WN3=0.15U WP1=0.15U WP2=0.15U WP3=0.15U
.ENDS me84a03_DEC3TO1B_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_PR8B_LC                                                              *
* LAST TIME SAVED:  MAY 08 15:23:08 2014                                      *
*******************************************************************************
.SUBCKT me84a03_PR8B_LC LA0QB LA0QT QB7 QB6 QB5 QB4 QB3 QB2 QB1 QB0 A2
+ A1 A0 CB CT LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO LA0QB:O LA0QT:O QB7:O QB6:O QB5:O QB4:O QB3:O QB2:O QB1:O QB0:O
*.PININFO A2:I A1:I A0:I CB:I CT:I
XI131 QB3 LA0QT LA1QT LA2QB me84a03_DEC3TO1B_LC
XI207 QB5 LA0QT LA1QB LA2QT me84a03_DEC3TO1B_LC
XI205 QB7 LA0QT LA1QT LA2QT me84a03_DEC3TO1B_LC
XI129 QB1 LA0QT LA1QB LA2QB me84a03_DEC3TO1B_LC
XI130 QB2 LA0QB LA1QT LA2QB me84a03_DEC3TO1B_LC
XI200 QB4 LA0QB LA1QB LA2QT me84a03_DEC3TO1B_LC
XI206 QB6 LA0QB LA1QT LA2QT me84a03_DEC3TO1B_LC
XI307 QB0 LA0QB LA1QB LA2QB me84a03_DEC3TO1B_LC
XI216 LA2QB LA2QT A2 CB CT me84a03_ADRLAT_LC
XI168 LA1QB LA1QT A1 CB CT me84a03_ADRLAT_LC
XI165 LA0QB LA0QT A0 CB CT me84a03_ADRLAT_LC
.ENDS me84a03_PR8B_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DEC2TO1_LC                                                           *
* LAST TIME SAVED:  MAY 08 15:23:10 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DEC2TO1_LC Q D0 D1 PRCLK
*.PININFO Q:O D0:I D1:I PRCLK:I
XI81 Q DD me84a03_INV LN=me84a03_LD LP=0.07U WN=3.5U WP=8.12U
XI63 DD PRCLK D0 D1 me84a03_ND3 LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=2.0U WN2=2.0U WN3=2.0U
+WP1=1.5U WP2=1.5U WP3=1.5U
.ENDS me84a03_DEC2TO1_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_PR4_LC                                                               *
* LAST TIME SAVED:  MAY 08 15:23:05 2014                                      *
*******************************************************************************
.SUBCKT me84a03_PR4_LC LA0QB LA0QT LA1QB LA1QT PRCHBR3 PRCHBR2 PRCHBR1 PRCHBR0
+A0 A1 CB CSHARE CT PRCLK LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO LA0QB:O LA0QT:O LA1QB:O LA1QT:O PRCHBR3:O PRCHBR2:O PRCHBR1:O PRCHBR0:O
*.PININFO A0:I A1:I CB:I CSHARE:I CT:I PRCLK:I
XI168 LA1QB LA1QT A1 CB CT me84a03_ADRLAT_LC
XI165 LA0QB LA0QT A0 CB CT me84a03_ADRLAT_LC
XI128 PRCHBR0 LA0QB LA1QB PRCLK me84a03_DEC2TO1_LC
XI129 PRCHBR1 LA0QT LA1QB PRCLK me84a03_DEC2TO1_LC
XI130 PRCHBR2 LA0QB CSHARE PRCLK me84a03_DEC2TO1_LC
XI131 PRCHBR3 LA0QT CSHARE PRCLK me84a03_DEC2TO1_LC
.ENDS me84a03_PR4_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ADRGEN_LC_32                                                         *
* LAST TIME SAVED:  MAY 08 15:23:09 2014                                      *
*******************************************************************************
.SUBCKT me84a03_ADRGEN_LC_32 LYA0QB LYA0QT LYA1QB LYA1QT PAB7 PAB6 PAB5 PAB4
+PAB3 PAB2 PAB1 PAB0 PBB3 PBB2 PBB1 PBB0 PRCHBR3 PRCHBR2
+PRCHBR1 PRCHBR0 CSHARE LCLKB LCLKT PRCLK QXA4 QXA3 QXA2 QXA1 QXA0
+ QYA1 QYA0 LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO LYA0QB:O LYA0QT:O LYA1QB:O LYA1QT:O PAB7:O PAB6:O PAB5:O PAB4:O PAB3:O
*.PININFO PAB2:O PAB1:O PAB0:O PBB3:O PBB2:O PBB1:O PBB0:O PRCHBR3:O
*.PININFO PRCHBR2:O PRCHBR1:O PRCHBR0:O CSHARE:I LCLKB:I LCLKT:I PRCLK:I QXA4:I
*.PININFO QXA3:I QXA2:I QXA1:I QXA0:I QYA1:I QYA0:I
XXB PBB3 PBB2 PBB1 PBB0 QXA4 QXA3 LCLKB LCLKT me84a03_PR4B_LC
XIXA RPAB1 RPAB0 PAB7 PAB6 PAB5 PAB4 PAB3 PAB2 PAB1 PAB0
+QXA2 QXA1 QXA0 LCLKB LCLKT me84a03_PR8B_LC
XXYM LYA0QB LYA0QT LYA1QB LYA1QT PRCHBR3 PRCHBR2 PRCHBR1 PRCHBR0 QYA0
+QYA1 LCLKB CSHARE LCLKT PRCLK me84a03_PR4_LC
.ENDS me84a03_ADRGEN_LC_32

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_L0B                                                                  *
* LAST TIME SAVED:  MAY 08 15:23:05 2014                                      *
*******************************************************************************
.SUBCKT me84a03_L0B QB CB CT IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO QB:O CB:I CT:I IN:I
XXG1 IN INB CB CT me84a03_TG LN=me84a03_LD LP=me84a03_LD WN=0.25U WP=0.5U
XI13 INB QB CT CB me84a03_CINV WN1=0.17U WN2=0.17U WP1=0.17U WP2=0.17U
XXII QB INB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.25U WP=0.5U
.ENDS me84a03_L0B

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_L1B                                                                  *
* LAST TIME SAVED:  MAY 08 15:23:11 2014                                      *
*******************************************************************************
.SUBCKT me84a03_L1B QB CB CT IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO QB:O CB:I CT:I IN:I
XXG1 IN INB CB CT me84a03_TG LN=me84a03_LD LP=me84a03_LD WN=.5U WP=1U
XI13 INB QB CT CB me84a03_CINV WN1=0.17U WN2=0.17U WP1=0.17U WP2=0.17U
XXII QB INB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.5U WP=1U
.ENDS me84a03_L1B

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_BEMX_CTRL                                                            *
* LAST TIME SAVED:  MAY 08 15:22:56 2014                                      *
*******************************************************************************
.SUBCKT me84a03_BEMX_CTRL QB QT A BCB BCT TA
*.PININFO QB:O QT:O A:I BCB:I BCT:I TA:I
XMI24 VDD BCT PA VDD P12_LP W=0.7U L=me84a03_LPD M=1
XMI28 PT TA QB VDD P12_LP W=0.7U L=me84a03_LPD M=1
XMI2 PA A QB VDD P12_LP W=0.7U L=me84a03_LPD M=1
XMI29 VDD BCB PT VDD P12_LP W=0.7U L=me84a03_LPD M=1
DI30 VSS TA NDIO12_LP AREA=ARD PJ=PRD
DI0 VSS A NDIO12_LP AREA=ARD PJ=PRD
XMN4 QB A NA VSS N12_LP W=0.35U L=me84a03_LND M=1
XMI26 QB TA NT VSS N12_LP W=0.35U L=me84a03_LND M=1
XMI25 NA BCB VSS VSS N12_LP W=0.35U L=me84a03_LND M=1
XMI27 NT BCT VSS VSS N12_LP W=0.35U L=me84a03_LND M=1
XXII QT QB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.36U WP=0.7U
.ENDS me84a03_BEMX_CTRL

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CTRL_LC                                                              *
* LAST TIME SAVED:  MAY 08 15:23:01 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CTRL_LC BCBR BCTR LME LWE LWEI LWER MCLK MERDA0 MERDA1 METRD QM SWBAWTBR
+ SWBAWTR T1B WEA0 WEA1 ADXOR AWT BISTE CB CLK CT ME SMERD SWE TCLK TEST1 TME
+TWE WE LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BCBR:O BCTR:O LME:O LWE:O LWEI:O LWER:O MCLK:O MERDA0:O MERDA1:O METRD:O QM:O
*.PININFO SWBAWTBR:O SWBAWTR:O T1B:O WEA0:O WEA1:O ADXOR:I AWT:I BISTE:I CB:I CLK:I CT:I
*.PININFO ME:I SMERD:I SWE:I TCLK:I TEST1:I TME:I TWE:I WE:I
XI58 METWRB SWE SMERD me84a03_ND2 WN1=0.7U WN2=0.7U WP1=0.7U WP2=0.7U
XXLWE LWE CB CT METWRB me84a03_L0B
DI44 VSS AWT NDIO12_LP AREA=ARD PJ=PRD
DI0 VSS TEST1 NDIO12_LP AREA=ARD PJ=PRD
DI37 VSS BISTE NDIO12_LP AREA=ARD PJ=PRD
XI43 METRDB SMERD me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.5U WP=1.0U
XI57 LWEI LWE me84a03_INV LN=0.07U LP=me84a03_LD WN=0.92U WP=1.5U
XI19 MCLKT MCLKB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.7U
XI149 METRD METRDB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI54 LWER LWEI me84a03_INV LN=me84a03_LD LP=0.07U WN=3U WP=6.96U
XXLME LME MCLKB MCLKT METRDB me84a03_L1B
XI14 NET0120 MERDA1 WEA1 me84a03_XOR2B LN2=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
XI7 NET0123 NET0120 ADXOR me84a03_XOR2B LN2=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
XXBMERD MERDA0 MERDA1 ME BCBR BCTR TME me84a03_BEMX_CTRL
XXBWE WEA0 WEA1 WE BCBR BCTR TWE me84a03_BEMX_CTRL
XXBMC MCLKB MCLK CLK BCBR BCTR TCLK me84a03_BEMX_CTRL
XI42 NET0175 NET0123 AWT me84a03_ND2H LN1=0.07U LN2=0.07U LP1=0.07U LP2=0.07U WN1=0.8U
+WN2=0.8U WP1=0.4U WP2=0.4U
XI124 BCTR BCBR me84a03_INVH LN=0.07U LP=0.07U WN=1.5U WP=3.0U
XI125 BCBR BISTE me84a03_INVH LN=0.07U LP=0.07U WN=1.5U WP=3.0U
XI50 SWBAWTR SWBAWTBR me84a03_INVH LN=0.07U LP=0.07U WN=1.5U WP=3.0U
XI26 T1B TEST1 me84a03_INVH LN=0.07U LP=0.07U WN=0.2U WP=0.4U
XI49 SWBAWTBR AWT me84a03_INVH LN=0.07U LP=0.07U WN=1.5U WP=3.0U
XI16 QM NET0175 me84a03_INVH LN=0.07U LP=0.07U WN=2.8U WP=1.4U
.ENDS me84a03_CTRL_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CCBUF_LC                                                             *
* LAST TIME SAVED:  MAY 08 15:23:00 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CCBUF_LC CCRDR SAPRB SAOFF
*.PININFO CCRDR:O SAPRB:O SAOFF:I
XI409 CCRDR SAPRB me84a03_INV LN=me84a03_LD LP=0.07U WN=2U WP=6.96U
XI355 SAPRT SAOFF me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.6U
XI410 SAPRB SAPRT me84a03_INV LN=0.07U LP=me84a03_LD WN=2.32U WP=1.5U
.ENDS me84a03_CCBUF_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WCLKBUF_LC                                                           *
* LAST TIME SAVED:  MAY 08 15:23:12 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WCLKBUF_LC WCLK1 WCLK0 WCLKB1 WCLKB0 WCT
*.PININFO WCLK1:O WCLK0:O WCLKB1:O WCLKB0:O WCT:I
XI11 WCLK1 WB me84a03_INV LN=me84a03_LD LP=0.07U WN=8.0U WP=18.56U
XI4 WCLK0 RFLOATT me84a03_INV LN=me84a03_LD LP=0.07U WN=8.0U WP=18.56U
XI12 RFLOATT WCT me84a03_INV LN=0.07U LP=me84a03_LD WN=2.32U WP=4.0U
XI14 WCLKB0 WCLK0 me84a03_INV LN=0.07U LP=me84a03_LD WN=2.32U WP=6.0U
XI13 WCLKB1 WCLK1 me84a03_INV LN=0.07U LP=me84a03_LD WN=2.32U WP=6.0U
XI19 WB WCT me84a03_INV LN=0.07U LP=me84a03_LD WN=2.32U WP=4.0U
.ENDS me84a03_WCLKBUF_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_SKWDLY                                                               *
* LAST TIME SAVED:  MAY 08 15:22:50 2014                                      *
*******************************************************************************
.SUBCKT me84a03_SKWDLY Z A
*.PININFO Z:O A:I
XMI239 Z N2 VDD VDD P12_LP W=0.6U L=me84a03_LD M=1
XMI221 N2 A VDD VDD P12_LP W=0.17U L=0.290U M=1
XMI243 Z N2 VSS VSS N12_LP W=0.2U L=me84a03_LD M=1
XMI226 N2 A VSS VSS N12_LP W=0.4U L=me84a03_LD M=1
.ENDS me84a03_SKWDLY

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_INVW                                                                 *
* LAST TIME SAVED:  MAY 07 12:39:32 2013                                      *
*******************************************************************************
.SUBCKT me84a03_INVW QN A LN=me84a03_LND LP=me84a03_LPD WN=me84a03_WND WP=me84a03_WPD
*.PININFO QN:O A:I
XMTP1 VDD A QN VDD P12_LP W=WP L=LP M=1
XMTN1 QN A VSS VSS N12_LP W=WN L=LN M=1
.ENDS me84a03_INVW

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CLOCK                                                                *
* LAST TIME SAVED:  MAY 08 15:23:00 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CLOCK FLOAT LCLKT BCB BCT CLK LME MCLK RST STCLK STCLKWR TCLK TEST1B
+LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO FLOAT:O LCLKT:O BCB:I BCT:I CLK:I LME:I MCLK:I RST:I STCLK:I STCLKWR:I TCLK:I
*.PININFO TEST1B:I
XMI560 VDD T1P FLOAT VDD P12_LP W=1.5U L=me84a03_LPD M=1
XMI31 VDD CLKLATB NET86 VDD P12_LP W=0.15U L=0.15U M=1
XMI42 VDD NET087 FLOAT VDD P12_LP W=1.35U L=me84a03_LPD M=1
XI523 GATE N me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI513 CLKLATB NET86 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI149 LCLKT FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.5U WP=4.5U
XI552 T1P CLK_TEST1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.3U
XI43 NET087 RST me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI527 NET063 MCLK me84a03_SKWDLY
XMI517 VDD MCLK NET86 VDD P12_LP W=0.5U L=me84a03_LPD M=1
XMI26 FLOAT STCLKWR VDD VDD P12_LP W=5.4U L=me84a03_LPD M=2
XMI693 FLOAT STCLK VDD VDD P12_LP W=5.4U L=me84a03_LPD M=2
DI71 VSS RST NDIO12_LP AREA=ARD PJ=PRD
XI551 CLK_TEST1 TEST1B MCLK me84a03_NR2 LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD WN1=0.15U WN2=0.15U
+ WP1=0.3U WP2=0.3U
XMI194 NET75 BCB NN VSS N12_LP W=5.4U L=me84a03_LD M=2
XMI193 NN GATE VSS VSS N12_LP W=5.4U L=me84a03_LD M=2
XMI521 NN0 MCLK VSS VSS N12_LP W=1.0U L=me84a03_LD M=1
XMI519 NET86 LCLKT NN0 VSS N12_LP W=1.0U L=me84a03_LD M=1
XMI28 FLOAT CLK NET75 VSS N12_LP W=5.4U L=me84a03_LD M=2
XMI33 NET60 MCLK VSS VSS N12_LP W=0.17U L=me84a03_LD M=1
XMI32 NET86 CLKLATB NET60 VSS N12_LP W=0.17U L=me84a03_LD M=1
XMI36 NET54 BCT NN VSS N12_LP W=5.4U L=me84a03_LD M=2
XMI35 FLOAT TCLK NET54 VSS N12_LP W=5.4U L=me84a03_LD M=2
XI27 N NET86 LME NET087 me84a03_ND3 WN1=1.0U WN2=1.0U WN3=1.0U WP1=0.5U WP2=0.5U WP3=0.4U
XI358 FLOAT LCLKT me84a03_INVW LN=0.12U WN=0.15U WP=0.8U
.ENDS me84a03_CLOCK

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CENRD_LC                                                             *
* LAST TIME SAVED:  MAY 08 15:22:56 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CENRD_LC CCOR CCRDR CCWR DCLKBR FLOATI LCLKB LCLKT PRCLKRD RDOFF SAOFF
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 FLOAT BCB BCT CLK LME LWE MCLK MET
+RST STCLK STCLKWR T1B TCLK LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO CCOR:O CCRDR:O CCWR:O DCLKBR:O FLOATI:O LCLKB:O LCLKT:O PRCLKRD:O RDOFF:O
*.PININFO SAOFF:O WCLKRD1:O WCLKRD0:O WCLKRDB1:O WCLKRDB0:O FLOAT:B BCB:I BCT:I
*.PININFO CLK:I LME:I LWE:I MCLK:I MET:I RST:I STCLK:I STCLKWR:I T1B:I TCLK:I
XI60 CCWR CCWRB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI52 LCLKB LCLKT me84a03_INV LP=0.07U WN=1.5U WP=5.22U
XI32 LWEB LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.3U
XI49 NET098 LMELCLKB me84a03_INV LP=0.07U WN=0.7U WP=1.62U
XI45 FBR FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.3U
XI29 LMECT LMECB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI34 CCOR CCORB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI44 FBW FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI54 DCLKBR FLOATI me84a03_INV LN=0.07U LP=me84a03_LD WN=3.48U WP=6U
XI57 LMECB FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI50 RDOFF NET098 me84a03_INV LN=0.07U LP=me84a03_LD WN=4.64U WP=4U
XI53 FLOATI FLOAT me84a03_INV LN=me84a03_LD LP=0.07U WN=2U WP=4.64U
XI48 PRCLKRD FLOAT me84a03_INV LP=0.07U WN=4U WP=5.8U
XI15 CCRDR SAOFF CCORB me84a03_CCBUF_LC
XXWC WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 WCTRD me84a03_WCLKBUF_LC
XI915 FLOAT WCTRD BCB BCT CLK LME MCLK RST STCLK STCLKWR TCLK T1B me84a03_CLOCK
XI24 LMELCLKB LMECT LMECB MET me84a03_L0B
XI61 CCWRB FBW LWE T1B me84a03_ND3 WN1=0.5U WN2=0.5U WN3=0.5U WP1=0.5U WP2=0.5U WP3=0.5U
XI43 CCORB FBR LWEB me84a03_ND2 WN1=1.0U WN2=1.0U WP1=1.0U WP2=1.0U
XI56 LCLKT FLOAT MET me84a03_ND2 WN1=3.0U WN2=3.0U WP1=3.0U WP2=1.0U
.ENDS me84a03_CENRD_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CENTER_SD_LC_32                                                      *
* LAST TIME SAVED:  MAY 08 15:22:50 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CENTER_SD_LC_32 ACUTRK AWT BCBR BCTR BISTE CCOR CCRDR CCWR CLK DCLKBR
+FLOATI LOG0 LOG1 LWEI LWER MCLK ME MERDA0 MERDA1 PARDB0 PARDB1 PARDB2
+PARDB3 PARDB4 PARDB5 PARDB6 PARDB7 PBRDB0 PBRDB1 PBRDB2
+PBRDB3 PCBR0 PCBR1 PCBR2 PCBR3 PRCLKRD PRM00 PRM01 PRM02
+PRM03 PRM04 PRM10 PRM11 PRM12 PRM13 PRM14 QM RCSHARE RDOFF
+RLYA0QB RLYA0QT RLYA1QB RLYA1QT RMDEF0 RMDEF1 RMDEF2 RMEN RMENB RMENI0
+RMENI1 RMEXT0 RMEXT1 RMEXT2 RMEXT3 RMFAST0 RMFAST1 RMFAST2
+RMSLOW0 RMSLOW1 RMSLOW2 RST RW_RBL SAEBRT SAOFF SMERD STCLK STCLKWR
+SWBAWTBR SWBAWTR SWE T1B TCLK TEST1 TME TWE TXARD0 TXARD1 TXARD2 TXARD3
+ TXARD4 TXARD5 TXARD6 TYARD0 TYARD1 WCLKRD0 WCLKRD1 WCLKRDB0
+WCLKRDB1 WE WEA0 WEA1 XARD0 XARD1 XARD2 XARD3 XARD4 XARD5 XARD6
+ YARD0 YARD1 Z0 Z0B Z1 Z2 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LN3=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD
+ LP2=me84a03_LPD LP3=me84a03_LPD
*.PININFO ACUTRK:O AWT:I BCBR:O BCTR:O BISTE:I CCOR:O CCRDR:O CCWR:O CLK:I DCLKBR:O
*.PININFO FLOATI:O LOG0:B LOG1:B LWEI:O LWER:O MCLK:O ME:I MERDA0:O MERDA1:O PARDB0:O
*.PININFO PARDB1:O PARDB2:O PARDB3:O PARDB4:O PARDB5:O PARDB6:O PARDB7:O
*.PININFO PBRDB0:O PBRDB1:O PBRDB2:O PBRDB3:O PCBR0:O PCBR1:O PCBR2:O
*.PININFO PCBR3:O PRCLKRD:O PRM00:B PRM01:B PRM02:B PRM03:B PRM04:B PRM10:B
*.PININFO PRM11:B PRM12:B PRM13:B PRM14:B QM:O RCSHARE:I RDOFF:O RLYA0QB:O
*.PININFO RLYA0QT:O RLYA1QB:O RLYA1QT:O RMDEF0:I RMDEF1:I RMDEF2:I RMEN:I RMENB:O
*.PININFO RMENI0:I RMENI1:I RMEXT0:I RMEXT1:I RMEXT2:I RMEXT3:I RMFAST0:I
*.PININFO RMFAST1:I RMFAST2:I RMSLOW0:I RMSLOW1:I RMSLOW2:I RST:I RW_RBL:O
*.PININFO SAEBRT:B SAOFF:O SMERD:I STCLK:I STCLKWR:I SWBAWTBR:O SWBAWTR:O SWE:I T1B:O
*.PININFO TCLK:I TEST1:I TME:I TWE:I TXARD0:I TXARD1:I TXARD2:I TXARD3:I
*.PININFO TXARD4:I TXARD5:I TXARD6:I TYARD0:I TYARD1:I WCLKRD0:O WCLKRD1:O
*.PININFO WCLKRDB0:O WCLKRDB1:O WE:I WEA0:O WEA1:O XARD0:I XARD1:I XARD2:I
*.PININFO XARD3:I XARD4:I XARD5:I XARD6:I YARD0:I YARD1:I Z0:O Z0B:O Z1:O
*.PININFO Z2:O
XI37 LOG0 me84a03_LOG
XI56 ACUTRK RMENB RW_RBL Z0B Z2 Z1 Z0 PRM04 PRM03 PRM02 PRM01
+PRM00 PRM14 PRM13 PRM12 PRM11 PRM10 RMDEF2 RMDEF1 RMDEF0 RMEN
+RMENI1 RMENI0 RMEXT3 RMEXT2 RMEXT1 RMEXT0 RMFAST2 RMFAST1
+RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 me84a03_RMMX_LC
XXADRRDMUX ADXOR QXARD6 QXARD5 QXARD4 QXARD3 QXARD2 QXARD1 QXARD0
+QYARD1 QYARD0 BCBR BCTR TXARD6 TXARD5 TXARD4 TXARD3 TXARD2
+TXARD1 TXARD0 TYARD1 TYARD0 XARD6 XARD5 XARD4 XARD3 XARD2
+XARD1 XARD0 YARD1 YARD0 me84a03_ADRMUX
XMI46 VDD LOG0 LOG1 VDD P12_LP W=6.0U L=me84a03_LD M=1
XXADRD RLYA0QB RLYA0QT RLYA1QB RLYA1QT PARDB7 PARDB6 PARDB5 PARDB4
+PARDB3 PARDB2 PARDB1 PARDB0 PBRDB3 PBRDB2 PBRDB1 PBRDB0 PCBR3
+ PCBR2 PCBR1 PCBR0 RCSHARE LCLKBRD LCLKTRD PRCLKRD QXARD4 QXARD3
+QXARD2 QXARD1 QXARD0 QYARD1 QYARD0 me84a03_ADRGEN_LC_32
XXR BCBR BCTR LME LWE LWEI LWER MCLK MERDA0 MERDA1 METRD QM SWBAWTBR SWBAWTR T1B
+ WEA0 WEA1 ADXOR AWT BISTE LCLKBRD CLK LCLKTRD ME SMERD SWE TCLK TEST1 TME TWE
+WE me84a03_CTRL_LC
XXCENRD CCOR CCRDR CCWR DCLKBR FLOATI LCLKBRD LCLKTRD PRCLKRD RDOFF SAOFF
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 RFLOAT BCBR BCTR CLK LME LWE MCLK
+METRD RST STCLK STCLKWR T1B TCLK me84a03_CENRD_LC
XMI45 VSS LOG1 LOG0 VSS N12_LP W=6.0U L=me84a03_LD M=1
.ENDS me84a03_CENTER_SD_LC_32

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WRDRV_LITE_LC                                                        *
* LAST TIME SAVED:  MAY 08 15:23:12 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WRDRV_LITE_LC WRB WRT DCLKB D_AH LWE WEM_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD
+ LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO WRB:O WRT:O DCLKB:I D_AH:I LWE:I WEM_IN:I
XI1 NET057 WEM_IN me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI3 NET55 NET057 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI4 WEMB NET55 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI6 NET51 D_AH me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI7 NET49 NET51 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI8 DIB NET49 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI15 NET064 LDIB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XXID LDIB LDIT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI16 WRT NET24 me84a03_INVH LN=0.07U LP=me84a03_LD WN=2.31U WP=0.6U
XI17 WRB NET21 me84a03_INVH LN=0.07U LP=me84a03_LD WN=2.31U WP=0.6U
XI40 DICB DICT me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI41 DICT DCLKB me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.3U
XXWEM LLWE DICB DICT WEMB me84a03_L2BIO
XXDA LDIT DICB DICT DIB me84a03_L2BIO
XI29 NET21 NET076 LDIB me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U WP1=0.3U
+ WP2=0.3U
XI28 NET24 NET076 NET064 me84a03_NR2H LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U
+WP1=0.3U WP2=0.3U
XI22 NET076 LWE LLWE me84a03_ND2H WN1=0.34U WN2=0.34U WP1=0.15U WP2=0.15U
.ENDS me84a03_WRDRV_LITE_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2SW_LITE_LC                                                      *
* LAST TIME SAVED:  MAY 08 15:23:12 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2SW_LITE_LC BB0 BB1 BT0 BT1 CCRD DA DCLKB LOG0 LOG1 LWE0
+LWE1 PCB0 PCB1 Q SAEB WEMA WEMA_AH WEMA_AL WEMA_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND
+ LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE0:I
*.PININFO LWE1:I PCB0:B PCB1:B Q:O SAEB:I WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET028 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDO NET25 Q WEMA_AH WEMA_AL DA LQT WEMA me84a03_DO_LITE_LC
DI29 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI30 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2
XXDI WRB WRT DCLKB NET25 LWE0 WEMA_IN me84a03_WRDRV_LITE_LC
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET029 CCRD me84a03_LSA1
XI36 NET029 SAEB NET028 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2SW_LITE_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WRDRV_LITE                                                           *
* LAST TIME SAVED:  MAY 08 15:22:55 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WRDRV_LITE WRB WRT DCLKB D_AH LWE WEM_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD
+LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO WRB:O WRT:O DCLKB:I D_AH:I LWE:I WEM_IN:I
XXWEM LLWE DICB DICT WEMB me84a03_L2BIO
XXDA LDIT DICB DICT DIB me84a03_L2BIO
XI1 NET057 WEM_IN me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI3 NET55 NET057 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI4 WEMB NET55 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI6 NET51 D_AH me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI7 NET49 NET51 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI8 DIB NET49 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI15 NET064 LDIB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XXID LDIB LDIT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.15U
XI16 WRT NET24 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.01U WP=0.6U
XI17 WRB NET21 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.01U WP=0.6U
XI40 DICB DICT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.17U
XI41 DICT DCLKB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.3U
XI29 NET21 NET076 LDIB me84a03_NR2 LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U WP1=0.3U
+ WP2=0.3U
XI28 NET24 NET076 NET064 me84a03_NR2 LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U
+WP1=0.3U WP2=0.3U
XI22 NET076 LWE LLWE me84a03_ND2 WN1=0.34U WN2=0.34U WP1=0.15U WP2=0.15U
.ENDS me84a03_WRDRV_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DO_LITE                                                              *
* LAST TIME SAVED:  MAY 08 15:23:06 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DO_LITE D_AH Q WEM_AH WEM_AL D LQT WEM
*.PININFO D_AH:O Q:O WEM_AH:O WEM_AL:O D:I LQT:I WEM:I
XI38 WEM_AL WEM me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
XI36 D_AH NET18 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
XI39 WEM_AH WEM_AL me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
XI30 NET21 LQT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.38U WP=.76U
XI29 Q NET21 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.2U WP=2.4U
XI37 NET18 D me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
.ENDS me84a03_DO_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2SW_LITE                                                         *
* LAST TIME SAVED:  MAY 08 15:22:57 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2SW_LITE BB0 BB1 BT0 BT1 CCRD DA DCLKB LOG0 LOG1 LWE0
+LWE1 PCB0 PCB1 Q SAEB WEMA WEMA_AH WEMA_AL WEMA_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND
+ LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE0:I
*.PININFO LWE1:I PCB0:B PCB1:B Q:O SAEB:I WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2
XXDI WRB WRT DCLKB NET25 LWE0 WEMA_IN me84a03_WRDRV_LITE
DI29 VSS DA NDIO12_LP AREA=ARD PJ=PRD
DI30 VSS WEMA NDIO12_LP AREA=ARD PJ=PRD
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET028 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDO NET25 Q WEMA_AH WEMA_AL DA LQT WEMA me84a03_DO_LITE
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET029 CCRD me84a03_LSA1
XI38 NET029 SAEB NET028 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2SW_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DO                                                                   *
* LAST TIME SAVED:  MAY 08 15:23:10 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DO D_AH Q WEM_AH WEM_AL BCB BCT DA LQT SWBAWT SWBAWTB TDA TWEMA WEMA LN=me84a03_LND
+ LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO D_AH:O Q:O WEM_AH:O WEM_AL:O BCB:I BCT:I DA:I LQT:I SWBAWT:I SWBAWTB:I TDA:I
*.PININFO TWEMA:I WEMA:I
XI25 NET38 D_AH DA BCB BCT TDA me84a03_BEMXIO
XI24 WEM_AL WEM_AH WEMA BCB BCT TWEMA me84a03_BEMXIO
XI33 NET46 D_AH NET38 WEM_AH WEM_AL me84a03_IMX2XOR
XI57 QB NET46 SWBAWT SWBAWTB me84a03_CINVW WN1=0.2U WN2=0.2U WP1=0.4U WP2=0.4U
XI97 QB LQT SWBAWTB SWBAWT me84a03_CINVW WN1=0.76U WN2=0.76U WP1=1.0U WP2=1.0U
XI4 Q QB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.2U WP=2.4U
.ENDS me84a03_DO

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2SW                                                              *
* LAST TIME SAVED:  MAY 08 15:23:03 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2SW BB0 BB1 BCB BCT BT0 BT1 CCRD DA DCLKB LOG0 LOG1 LWE0
+LWE1 PCB0 PCB1 Q SAEB SWBAWT SWBAWTB TDA TWEMA WEMA WEMA_AH WEMA_AL
+WEMA_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BCB:I BCT:I BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B
*.PININFO LWE0:I LWE1:I PCB0:B PCB1:B Q:O SAEB:I SWBAWT:I SWBAWTB:I TDA:I TWEMA:I
*.PININFO WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XXDO NET37 Q WEMA_AH WEMA_AL BCB BCT DA LQT SWBAWT SWBAWTB TDA TWEMA WEMA me84a03_DO
XXDI WRB WRT DCLKB NET37 LWE0 WEMA_IN me84a03_WRDRV_LITE
DI30 VSS DA NDIO12_LP AREA=ARD PJ=PRD
DI34 VSS TDA NDIO12_LP AREA=ARD PJ=PRD
DI35 VSS TWEMA NDIO12_LP AREA=ARD PJ=PRD
DI29 VSS WEMA NDIO12_LP AREA=ARD PJ=PRD
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2
XXLSA SQB SQT RDT RDB SAE NET086 CCRD me84a03_LSA1
XI37 NET073 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XI27 NET086 SAEB NET073 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2SW

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2SW_LC                                                           *
* LAST TIME SAVED:  MAY 08 15:23:04 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2SW_LC BB0 BB1 BCB BCT BT0 BT1 CCRD DA DCLKB LOG0 LOG1
+LWE0 LWE1 PCB0 PCB1 Q SAEB SWBAWT SWBAWTB TDA TWEMA WEMA WEMA_AH
+WEMA_AL WEMA_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BCB:I BCT:I BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B
*.PININFO LWE0:I LWE1:I PCB0:B PCB1:B Q:O SAEB:I SWBAWT:I SWBAWTB:I TDA:I TWEMA:I
*.PININFO WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2
XXLSA SQB SQT RDT RDB SAE NET086 CCRD me84a03_LSA1
XI37 NET073 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDO NET37 Q WEMA_AH WEMA_AL BCB BCT DA LQT SWBAWT SWBAWTB TDA TWEMA WEMA me84a03_DO_LC
DI30 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI34 VSS TDA HVTNDIO12_LP AREA=ARD PJ=PRD
DI35 VSS TWEMA HVTNDIO12_LP AREA=ARD PJ=PRD
DI29 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXDI WRB WRT DCLKB NET37 LWE0 WEMA_IN me84a03_WRDRV_LITE_LC
XI36 NET086 SAEB NET073 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2SW_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM4_LITE_LC_16                                                     *
* LAST TIME SAVED:  MAY 08 15:23:03 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM4_LITE_LC_16 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 CCRD DA
+ DCLKB LOG0 LOG1 LWE PCB0 PCB1 PCB2 PCB3 Q SAEB WEMA WEMA_AH WEMA_AL
+WEMA_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BB2:B BB3:B BT0:B BT1:B BT2:B BT3:B CCRD:I DA:I
*.PININFO DCLKB:I LOG0:B LOG1:B LWE:I PCB0:B PCB1:B PCB2:B PCB3:B Q:O SAEB:I
*.PININFO WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET040 LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET041 CCRD me84a03_LSA1
XXMX BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 RDB RDT WRB WRT PCB3
+PCB2 PCB1 PCB0 me84a03_CMUX4_16
DI34 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI33 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXDI WRB WRT DCLKB NET28 LWE WEMA_IN me84a03_WRDRV_LITE_LC_16
XI31 NET28 Q WEMA_AH WEMA_AL DA LQT WEMA me84a03_DO_LITE_LC
XI36 NET041 SAEB NET040 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM4_LITE_LC_16

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM4_LITE_LC_8                                                      *
* LAST TIME SAVED:  MAY 08 15:23:05 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM4_LITE_LC_8 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 CCRD DA
+DCLKB LOG0 LOG1 LWE PCB0 PCB1 PCB2 PCB3 Q SAEB WEMA WEMA_AH WEMA_AL
+WEMA_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BB2:B BB3:B BT0:B BT1:B BT2:B BT3:B CCRD:I DA:I
*.PININFO DCLKB:I LOG0:B LOG1:B LWE:I PCB0:B PCB1:B PCB2:B PCB3:B Q:O SAEB:I
*.PININFO WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI29 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET036 LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET037 CCRD me84a03_LSA1
XXMX BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 RDB RDT WRB WRT PCB3
+PCB2 PCB1 PCB0 me84a03_CMUX4_8
DI34 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI33 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXDI WRB WRT DCLKB NET28 LWE WEMA_IN me84a03_WRDRV_LITE_LC_8
XI31 NET28 Q WEMA_AH WEMA_AL DA LQT WEMA me84a03_DO_LITE_LC
XI36 NET037 SAEB NET036 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM4_LITE_LC_8

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DO2_LITE_LC                                                          *
* LAST TIME SAVED:  MAY 08 15:23:11 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DO2_LITE_LC D_AH Q D LQT
*.PININFO D_AH:O Q:O D:I LQT:I
XI36 D_AH NET18 me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
XI30 NET21 LQT me84a03_INVH LN=0.07U LP=0.07U WN=0.44U WP=.88U
XI29 Q NET21 me84a03_INVH LN=0.07U LP=.07U WN=1.4U WP=2.8U
XI37 NET18 D me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=0.17U WP=0.34U
.ENDS me84a03_DO2_LITE_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2_LITE_LC_16                                                     *
* LAST TIME SAVED:  MAY 08 15:22:54 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2_LITE_LC_16 BB0 BB1 BT0 BT1 CCRD DA DCLKB LOG0 LOG1 LWE0
+LWE1 PCB0 PCB1 Q SAEB LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE0:I
*.PININFO LWE1:I PCB0:B PCB1:B Q:O SAEB:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET028 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDI WRB WRT DCLKB NET19 LWE0 me84a03_WRDRV2_LITE_LC_16
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2_16
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET029 CCRD me84a03_LSA1
DI34 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
XI31 NET19 Q DA LQT me84a03_DO2_LITE_LC
XI36 NET029 SAEB NET028 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2_LITE_LC_16

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2_LITE_LC_8                                                      *
* LAST TIME SAVED:  MAY 08 15:22:57 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2_LITE_LC_8 BB0 BB1 BT0 BT1 CCRD DA DCLKB LOG0 LOG1 LWE0
+LWE1 PCB0 PCB1 Q SAEB LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE0:I
*.PININFO LWE1:I PCB0:B PCB1:B Q:O SAEB:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET028 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDI WRB WRT DCLKB NET19 LWE0 me84a03_WRDRV2_LITE_LC_8
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2_8
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET029 CCRD me84a03_LSA1
DI34 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
XI31 NET19 Q DA LQT me84a03_DO2_LITE_LC
XI36 NET029 SAEB NET028 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2_LITE_LC_8

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM4_LITE_LC_32                                                     *
* LAST TIME SAVED:  MAY 08 15:22:57 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM4_LITE_LC_32 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 CCRD DA
+ DCLKB LOG0 LOG1 LWE PCB0 PCB1 PCB2 PCB3 Q SAEB WEMA WEMA_AH WEMA_AL
+WEMA_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BB2:B BB3:B BT0:B BT1:B BT2:B BT3:B CCRD:I DA:I
*.PININFO DCLKB:I LOG0:B LOG1:B LWE:I PCB0:B PCB1:B PCB2:B PCB3:B Q:O SAEB:I
*.PININFO WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET040 LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET041 CCRD me84a03_LSA1
XXMX BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 RDB RDT WRB WRT PCB3
+PCB2 PCB1 PCB0 me84a03_CMUX4_32
DI34 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI33 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXDI WRB WRT DCLKB NET28 LWE WEMA_IN me84a03_WRDRV_LITE_LC_32
XI31 NET28 Q WEMA_AH WEMA_AL DA LQT WEMA me84a03_DO_LITE_LC
XI29 NET041 SAEB NET040 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM4_LITE_LC_32

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2_LITE_LC_32                                                     *
* LAST TIME SAVED:  MAY 08 15:23:12 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2_LITE_LC_32 BB0 BB1 BT0 BT1 CCRD DA DCLKB LOG0 LOG1 LWE0
+LWE1 PCB0 PCB1 Q SAEB LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE0:I
*.PININFO LWE1:I PCB0:B PCB1:B Q:O SAEB:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET028 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXDI WRB WRT DCLKB NET19 LWE0 me84a03_WRDRV2_LITE_LC_32
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2_32
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET029 CCRD me84a03_LSA1
DI34 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
XI31 NET19 Q DA LQT me84a03_DO2_LITE_LC
XI36 NET029 SAEB NET028 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2_LITE_LC_32

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ADRMUX_LITE                                                          *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_ADRMUX_LITE QXA6 QXA5 QXA4 QXA3 QXA2 QXA1 QXA0 QYA1
+QYA0 XA6 XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0
*.PININFO QXA6:O QXA5:O QXA4:O QXA3:O QXA2:O QXA1:O QXA0:O QYA1:O QYA0:O
*.PININFO XA6:I XA5:I XA4:I XA3:I XA2:I XA1:I XA0:I YA1:I YA0:I
DI43 VSS YA0 NDIO12_LP AREA=ARD PJ=PRD
DI42 VSS YA1 NDIO12_LP AREA=ARD PJ=PRD
DI40 VSS XA6 NDIO12_LP AREA=ARD PJ=PRD
DI39 VSS XA5 NDIO12_LP AREA=ARD PJ=PRD
DI38 VSS XA4 NDIO12_LP AREA=ARD PJ=PRD
DI33 VSS XA2 NDIO12_LP AREA=ARD PJ=PRD
DI28 VSS XA0 NDIO12_LP AREA=ARD PJ=PRD
DI30 VSS XA1 NDIO12_LP AREA=ARD PJ=PRD
DI32 VSS XA3 NDIO12_LP AREA=ARD PJ=PRD
XI230 NET110 YA0 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=.25U WP=.5U
XI231 NET111 YA1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=.25U WP=.5U
XI200 QYA0 NET110 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.44U WP=0.88U
XI201 QYA1 NET111 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.44U WP=0.88U
XI220 QXA0 NET150 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.44U WP=0.88U
XI221 QXA1 NET151 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.44U WP=0.88U
XI222 QXA2 NET152 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.44U WP=0.88U
XI223 QXA3 NET153 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.44U WP=0.88U
XI224 QXA4 NET154 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.44U WP=0.88U
XI225 QXA5 NET155 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.44U WP=0.88U
XI226 QXA6 NET156 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.44U WP=0.88U
XI180 NET150 XA0 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=.25U WP=.5U
XI181 NET151 XA1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=.25U WP=.5U
XI182 NET152 XA2 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=.25U WP=.5U
XI183 NET153 XA3 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=.25U WP=.5U
XI184 NET154 XA4 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=.25U WP=.5U
XI185 NET155 XA5 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=.25U WP=.5U
XI186 NET156 XA6 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=.25U WP=.5U
.ENDS me84a03_ADRMUX_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CLOCK_LITE                                                           *
* LAST TIME SAVED:  MAY 08 15:22:56 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CLOCK_LITE FLOAT LCLKT CLK LME MCLK RST STCLK STCLKWR TEST1B LN1=me84a03_LND
+LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO FLOAT:O LCLKT:O CLK:I LME:I MCLK:I RST:I STCLK:I STCLKWR:I TEST1B:I
XMI560 VDD T1P FLOAT VDD P12_LP W=1.5U L=me84a03_LPD M=1
XMI31 VDD CLKLATB NET86 VDD P12_LP W=0.15U L=0.15U M=1
XMI44 VDD NET068 FLOAT VDD P12_LP W=1.35U L=me84a03_LPD M=1
XI523 GATE N me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI513 CLKLATB NET86 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI149 LCLKT FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.5U WP=4.5U
XI552 T1P CLK_TEST1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.3U
XI43 NET068 RST me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI527 DEL MCLK me84a03_SKWDLY
XMI517 VDD DEL NET86 VDD P12_LP W=0.5U L=me84a03_LPD M=1
XMI26 FLOAT STCLKWR VDD VDD P12_LP W=5.4U L=me84a03_LPD M=2
XMI693 FLOAT STCLK VDD VDD P12_LP W=5.4U L=me84a03_LPD M=2
DI71 VSS RST NDIO12_LP AREA=ARD PJ=PRD
XI551 CLK_TEST1 TEST1B MCLK me84a03_NR2 LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD WN1=0.15U WN2=0.15U
+ WP1=0.3U WP2=0.3U
XMI193 NN GATE VSS VSS N12_LP W=5.4U L=me84a03_LD M=2
XMI521 NN0 MCLK VSS VSS N12_LP W=1.0U L=me84a03_LD M=1
XMI519 NET86 LCLKT NN0 VSS N12_LP W=1.0U L=me84a03_LD M=1
XMI28 FLOAT CLK NN VSS N12_LP W=5.4U L=me84a03_LD M=2
XMI33 NET60 MCLK VSS VSS N12_LP W=0.17U L=me84a03_LD M=1
XMI32 NET86 CLKLATB NET60 VSS N12_LP W=0.17U L=me84a03_LD M=1
XI42 N NET86 LME NET068 me84a03_ND3 WN1=1.0U WN2=1.0U WN3=1.0U WP1=0.5U WP2=0.5U WP3=0.4U
XI358 FLOAT LCLKT me84a03_INVW LN=0.12U WN=0.15U WP=0.8U
.ENDS me84a03_CLOCK_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CENRD_LITE_LC                                                        *
* LAST TIME SAVED:  MAY 08 15:23:11 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CENRD_LITE_LC CCOR CCRDR CCWR DCLKBR FLOATI LCLKB LCLKT PRCLKRD RDOFF
+SAOFF WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 FLOAT CLK LME LWE MCLK MET RST
+STCLK STCLKWR T1B LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO CCOR:O CCRDR:O CCWR:O DCLKBR:O FLOATI:O LCLKB:O LCLKT:O PRCLKRD:O RDOFF:O
*.PININFO SAOFF:O WCLKRD1:O WCLKRD0:O WCLKRDB1:O WCLKRDB0:O FLOAT:B CLK:I LME:I
*.PININFO LWE:I MCLK:I MET:I RST:I STCLK:I STCLKWR:I T1B:I
XI60 CCWR CCWRB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI52 LCLKB LCLKT me84a03_INV LP=0.07U WN=1.5U WP=5.22U
XI32 LWEB LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.3U
XI49 NET098 LMELCLKB me84a03_INV LP=0.07U WN=0.7U WP=1.62U
XI45 FBR FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.3U
XI29 LMECT LMECB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI44 FBW FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI34 CCOR CCORB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI54 DCLKBR FLOATI me84a03_INV LN=0.07U LP=me84a03_LD WN=3.48U WP=6U
XI57 LMECB FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI50 RDOFF NET098 me84a03_INV LN=0.07U LP=me84a03_LD WN=4.64U WP=4U
XI53 FLOATI FLOAT me84a03_INV LN=me84a03_LD LP=0.07U WN=2U WP=4.64U
XI48 PRCLKRD FLOAT me84a03_INV LP=0.07U WN=4U WP=5.8U
XI915 FLOAT WCTRD CLK LME MCLK RST STCLK STCLKWR T1B me84a03_CLOCK_LITE
XI15 CCRDR SAOFF CCORB me84a03_CCBUF_LC
XXWC WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 WCTRD me84a03_WCLKBUF_LC
XI24 LMELCLKB LMECT LMECB MET me84a03_L0B
XI61 CCWRB FBW LWE T1B me84a03_ND3 WN1=0.5U WN2=0.5U WN3=0.5U WP1=0.5U WP2=0.5U WP3=0.5U
XI43 CCORB FBR LWEB me84a03_ND2 WN1=1.0U WN2=1.0U WP1=1.0U WP2=1.0U
XI56 LCLKT FLOAT MET me84a03_ND2 WN1=3.0U WN2=3.0U WP1=3.0U WP2=1.0U
.ENDS me84a03_CENRD_LITE_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CTRL_LITE_LC                                                         *
* LAST TIME SAVED:  MAY 08 15:23:00 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CTRL_LITE_LC LME LWE LWEI LWER MCLK MERDA0 MERDA1 METRD T1B WEA0 WEA1 CB
+ CLK CT ME SMERD SWE TEST1 WE LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO LME:O LWE:O LWEI:O LWER:O MCLK:O MERDA0:O MERDA1:O METRD:O T1B:O WEA0:O WEA1:O
*.PININFO CB:I CLK:I CT:I ME:I SMERD:I SWE:I TEST1:I WE:I
XI43 METRDB SMERD me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.5U WP=1.0U
XI62 MERDA1 MERDA0 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.7U
XI61 MERDA0 ME me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.7U
XI60 WEA0 WE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.7U
XI19 MCLKT MCLKB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.7U
XI149 METRD METRDB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI67 LWEI LWE me84a03_INV LN=0.07U LP=me84a03_LD WN=0.92U WP=1.5U
XI59 WEA1 WEA0 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.7U
XI65 LWER LWEI me84a03_INV LN=me84a03_LD LP=0.07U WN=3U WP=6.96U
XI64 MCLK MCLKB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.0U WP=8.0U
XI63 MCLKB CLK me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=3.2U WP=3.2U
XXLWE LWE CB CT METWRB me84a03_L0B
XXLME LME MCLKB MCLKT METRDB me84a03_L1B
DI0 VSS TEST1 NDIO12_LP AREA=ARD PJ=PRD
DI72 VSS WE NDIO12_LP AREA=ARD PJ=PRD
DI71 VSS ME NDIO12_LP AREA=ARD PJ=PRD
DI68 VSS CLK NDIO12_LP AREA=ARD PJ=PRD
XI58 METWRB SWE SMERD me84a03_ND2 WN1=0.7U WN2=0.7U WP1=0.7U WP2=0.7U
XI26 T1B TEST1 me84a03_INVH LN=0.07U LP=0.07U WN=0.2U WP=0.4U
.ENDS me84a03_CTRL_LITE_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CENTER_SD_LITE_LC_32                                                 *
* LAST TIME SAVED:  MAY 08 15:23:12 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CENTER_SD_LITE_LC_32 ACUTRK CCOR CCRDR CCWR CLK DCLKBR FLOATI LOG0 LOG1
+LWEI LWER MCLK ME MERDA0 MERDA1 PARDB0 PARDB1 PARDB2 PARDB3 PARDB4
+PARDB5 PARDB6 PARDB7 PBRDB0 PBRDB1 PBRDB2 PBRDB3 PCBR0 PCBR1
+PCBR2 PCBR3 PRCLKRD PRM00 PRM01 PRM02 PRM03 PRM04 PRM10 PRM11
+ PRM12 PRM13 PRM14 RCSHARE RDOFF RLYA0QB RLYA0QT RLYA1QB RLYA1QT RMDEF0
+ RMDEF1 RMDEF2 RMEN RMENB RMENI0 RMENI1 RMEXT0 RMEXT1 RMEXT2
+RMEXT3 RMFAST0 RMFAST1 RMFAST2 RMSLOW0 RMSLOW1 RMSLOW2 RST RW_RBL
+ SAEBRT SAOFF SMERD STCLK STCLKWR SWE T1B TEST1 WCLKRD0 WCLKRD1 WCLKRDB0
+WCLKRDB1 WE WEA0 WEA1 XARD0 XARD1 XARD2 XARD3 XARD4 XARD5 XARD6
+ YARD0 YARD1 Z0 Z0B Z1 Z2 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LN3=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD
+ LP2=me84a03_LPD LP3=me84a03_LPD
*.PININFO ACUTRK:O CCOR:O CCRDR:O CCWR:O CLK:I DCLKBR:O FLOATI:O LOG0:B LOG1:B LWEI:O
*.PININFO LWER:O MCLK:O ME:I MERDA0:O MERDA1:O PARDB0:O PARDB1:O PARDB2:O PARDB3:O
*.PININFO PARDB4:O PARDB5:O PARDB6:O PARDB7:O PBRDB0:O PBRDB1:O PBRDB2:O
*.PININFO PBRDB3:O PCBR0:O PCBR1:O PCBR2:O PCBR3:O PRCLKRD:O PRM00:B PRM01:B
*.PININFO PRM02:B PRM03:B PRM04:B PRM10:B PRM11:B PRM12:B PRM13:B PRM14:B
*.PININFO RCSHARE:I RDOFF:O RLYA0QB:O RLYA0QT:O RLYA1QB:O RLYA1QT:O RMDEF0:I RMDEF1:I
*.PININFO RMDEF2:I RMEN:I RMENB:O RMENI0:I RMENI1:I RMEXT0:I RMEXT1:I RMEXT2:I
*.PININFO RMEXT3:I RMFAST0:I RMFAST1:I RMFAST2:I RMSLOW0:I RMSLOW1:I
*.PININFO RMSLOW2:I RST:I RW_RBL:O SAEBRT:B SAOFF:O SMERD:I STCLK:I STCLKWR:I SWE:I
*.PININFO T1B:O TEST1:I WCLKRD0:O WCLKRD1:O WCLKRDB0:O WCLKRDB1:O WE:I WEA0:O
*.PININFO WEA1:O XARD0:I XARD1:I XARD2:I XARD3:I XARD4:I XARD5:I XARD6:I
*.PININFO YARD0:I YARD1:I Z0:O Z0B:O Z1:O Z2:O
XI37 LOG0 me84a03_LOG
XXADRRDMUX QXARD6 QXARD5 QXARD4 QXARD3 QXARD2 QXARD1 QXARD0
+QYARD1 QYARD0 XARD6 XARD5 XARD4 XARD3 XARD2 XARD1 XARD0
+YARD1 YARD0 me84a03_ADRMUX_LITE
XI56 ACUTRK RMENB RW_RBL Z0B Z2 Z1 Z0 PRM04 PRM03 PRM02 PRM01
+PRM00 PRM14 PRM13 PRM12 PRM11 PRM10 RMDEF2 RMDEF1 RMDEF0 RMEN
+RMENI1 RMENI0 RMEXT3 RMEXT2 RMEXT1 RMEXT0 RMFAST2 RMFAST1
+RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 me84a03_RMMX_LC
XMI46 VDD LOG0 LOG1 VDD P12_LP W=6.0U L=me84a03_LD M=1
XXCENRD CCOR CCRDR CCWR DCLKBR FLOATI LCLKBRD LCLKTRD PRCLKRD RDOFF SAOFF
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 RFLOAT CLK LME LWE MCLK METRD RST
+STCLK STCLKWR T1B me84a03_CENRD_LITE_LC
XXR LME LWE LWEI LWER MCLK MERDA0 MERDA1 METRD T1B WEA0 WEA1 LCLKBRD CLK LCLKTRD
+ ME SMERD SWE TEST1 WE me84a03_CTRL_LITE_LC
XXADRD RLYA0QB RLYA0QT RLYA1QB RLYA1QT PARDB7 PARDB6 PARDB5 PARDB4
+PARDB3 PARDB2 PARDB1 PARDB0 PBRDB3 PBRDB2 PBRDB1 PBRDB0 PCBR3
+ PCBR2 PCBR1 PCBR0 RCSHARE LCLKBRD LCLKTRD PRCLKRD QXARD4 QXARD3
+QXARD2 QXARD1 QXARD0 QYARD1 QYARD0 me84a03_ADRGEN_LC_32
XMI45 VSS LOG1 LOG0 VSS N12_LP W=6.0U L=me84a03_LD M=1
.ENDS me84a03_CENTER_SD_LITE_LC_32

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CAP_RT                                                               *
* LAST TIME SAVED:  MAY 08 15:23:13 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CAP_RT LOG0 LOG1
*.PININFO LOG0:B LOG1:B
XMI22 VDD LOG0 LOG1 VDD P12_LP W=3.62U L=me84a03_LD M=1
XMI23 VSS LOG1 LOG0 VSS N12_LP W=2.3U L=me84a03_LD M=1
.ENDS me84a03_CAP_RT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CAP_LT                                                               *
* LAST TIME SAVED:  MAY 08 15:23:11 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CAP_LT LOG0 LOG1
*.PININFO LOG0:B LOG1:B
XMI22 VDD LOG0 LOG1 VDD P12_LP W=3.62U L=me84a03_LD M=1
XMI23 VSS LOG1 LOG0 VSS N12_LP W=2.3U L=me84a03_LD M=1
.ENDS me84a03_CAP_LT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_STRAP                                                                *
* LAST TIME SAVED:  MAY 08 15:23:06 2014                                      *
*******************************************************************************
.SUBCKT me84a03_STRAP LOG0
*.PININFO LOG0:B
XMI271 VDD VDD VDD VDD PPU W=W1PU L=L1PU M=1
XMI0 VDD VDD VDD VDD PPU W=W1PU L=L1PU M=1
XMI4 VDD VDD VDD VDD PPU W=W1PU L=L1PU M=1
XMI3 VDD VDD VDD VDD PPU W=W1PU L=L1PU M=1
.ENDS me84a03_STRAP

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RAM_EDGE_REF                                                         *
* LAST TIME SAVED:  MAY 08 15:23:11 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RAM_EDGE_REF RBL WL
*.PININFO RBL:B WL:I
XMI268 VSS VSS VSS VSS NPD W=0.145U L=0.065U M=1
XMI0 VSS WL RBL VSS NPG W=0.095U L=0.075U M=1
.ENDS me84a03_RAM_EDGE_REF

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RAM_EDGE2_REF                                                        *
* LAST TIME SAVED:  MAY 08 15:22:58 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RAM_EDGE2_REF RBL WL0 WL1
*.PININFO RBL:B WL0:I WL1:I
XI3 RBL WL1 me84a03_RAM_EDGE_REF
XI2 RBL WL0 me84a03_RAM_EDGE_REF
.ENDS me84a03_RAM_EDGE2_REF

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RAM6X_SPLIT                                                          *
* LAST TIME SAVED:  MAY 08 15:22:50 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RAM6X_SPLIT BB BT NUBB NUBT RB RT SUP WL_RB WL_RT
*.PININFO BB:B BT:B NUBB:B NUBT:B RB:B RT:B SUP:I WL_RB:I WL_RT:I
XMI271 SUP RB RT VDD PPU W=W1PU L=L1PU M=1
XMI270 SUP RT RB VDD PPU W=W1PU L=L1PU M=1
XMI268 RT RB VSS VSS NPD W=W1PD L=L1PD M=1
XMI267 RB RT VSS VSS NPD W=W1PD L=L1PD M=1
XMI272 RB WL_RB NUBB VSS NPG W=W1PG L=L1PG M=1
XMI269 NUBT WL_RT RT VSS NPG W=W1PG L=L1PG M=1
.ENDS me84a03_RAM6X_SPLIT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_HS2LREF                                                              *
* LAST TIME SAVED:  MAY 08 15:23:07 2014                                      *
*******************************************************************************
.SUBCKT me84a03_HS2LREF LOG0 RBLRD RBLWR WL0 WL1 NET0 NET1
*.PININFO LOG0:B RBLRD:B RBLWR:B WL0:B WL1:B
XI50 RBLWR LOG0 LOG0 me84a03_RAM_EDGE2_REF
XI23 LOG0 RBLRD NET0 RBLRD LOG0 NET77 VDD WL0 LOG0 me84a03_RAM6X_SPLIT
XI22 LOG0 RBLRD NET1 RBLRD LOG0 NET76 VDD WL1 LOG0 me84a03_RAM6X_SPLIT
.ENDS me84a03_HS2LREF

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_STRAP_BOT                                                            *
* LAST TIME SAVED:  MAY 08 15:23:12 2014                                      *
*******************************************************************************
.SUBCKT me84a03_STRAP_BOT LOG0
*.PININFO LOG0:B
XMI271 VDD VDD VDD VDD PPU W=0.080U L=0.080U M=1
XMI0 VDD VDD VDD VDD PPU W=0.080U L=0.080U M=1
*MI4 NET016 VDD NET016 VDD PPU W=0.04U L=0.16U M=1
.ENDS me84a03_STRAP_BOT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_HSLREF                                                               *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_HSLREF LOG0 RBLRD RBLWR WL7 WL6 WL5 WL4 WL3 WL2 WL1 WL0
*.PININFO LOG0:B RBLRD:B RBLWR:B WL7:B WL6:B WL5:B WL4:B WL3:B WL2:B WL1:B
*.PININFO WL0:B
XI52 LOG0 me84a03_STRAP
XI48 LOG0 me84a03_STRAP
XIQ1 LOG0 RBLRD RBLWR WL2 WL3 NET2 NET1 me84a03_HS2LREF
XIQ0 LOG0 RBLRD RBLWR WL0 WL1 NET0 NET1 me84a03_HS2LREF
XI46 LOG0 RBLRD RBLWR WL4 WL5 NET2 NET5 me84a03_HS2LREF
XI45 LOG0 RBLRD RBLWR WL6 WL7 NET7 NET5 me84a03_HS2LREF
XI49 LOG0 me84a03_STRAP_BOT
.ENDS me84a03_HSLREF

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WARREF                                                               *
* LAST TIME SAVED:  MAY 08 15:23:13 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WARREF LOG0 LOG1 RBLRD RBLWR RWL RWLD
*.PININFO LOG0:B LOG1:B RBLRD:B RBLWR:B RWL:B RWLD:B
XI7 LOG0 me84a03_STRAP_BOT
XI4 LOG0 RBLRD NET0 RBLRD LOG0 NET34 VDD RWL LOG0 me84a03_RAM6X_SPLIT
XI22 LOG0 RBLRD NET1 RBLRD LOG0 NET35 VDD RWLD LOG0 me84a03_RAM6X_SPLIT
XI6 RBLWR LOG0 LOG0 me84a03_RAM_EDGE2_REF
.ENDS me84a03_WARREF

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_INV_PG                                                               *
* LAST TIME SAVED:  APR 24 16:12:33 2014                                      *
*******************************************************************************
.SUBCKT me84a03_INV_PG QN A PGN PGP LN=me84a03_LND LP=me84a03_LPD WN=me84a03_WND WP=me84a03_WPD
*.PININFO QN:O A:I PGN:I PGP:I
XMNA QN A PGN VSS N12_LP W=WN L=LN M=1
XMPA PGP A QN VDD P12_LP W=WP L=LP M=1
.ENDS me84a03_INV_PG

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RD_BUF                                                               *
* LAST TIME SAVED:  MAY 08 15:23:08 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RD_BUF VDDL WLB WLL
*.PININFO VDDL:B WLB:I WLL:O
XI9 WLL WLB VSS VDDL me84a03_INV_PG LN=me84a03_LD LP=me84a03_LD WN=5.0U WP=10.0U
.ENDS me84a03_RD_BUF

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RAM6X_XPM_WK                                                         *
* LAST TIME SAVED:  MAY 08 15:23:07 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RAM6X_XPM_WK BT RB DEF WL WLOFF
*.PININFO BT:B RB:B DEF:I WL:I WLOFF:I
XMI271 VDD RB RT1 VDD PPU W=W1PU L=L1PU M=1
XMI25 VDD RB RT2 VDD PPU W=W1PU L=L1PU M=1
XMI270 VDD RT1 RB VDD PPU W=W1PU L=L1PU M=1
XMI4 VDD WLOFF RT1 VDD P12_LP W=0.15U L=me84a03_LD M=1
XMI24 VDD RT2 RB VDD PPU W=W1PU L=L1PU M=1
XMPRPG2 VDD WLOFF RT2 VDD P12_LP W=0.15U L=me84a03_LD M=1
XMI267 RB RT1 VSS VSS NPD W=W1PD L=L1PD M=1
XMI269 RTCOM WL RT1 VSS NPG W=W1PG L=L1PG M=1
XMI21 RB RT2 VSS VSS NPD W=W1PD L=L1PD M=1
XMI19 RTCOM WL RT2 VSS NPG W=W1PG L=L1PG M=1
XMI32 BT WL RTCOM VSS NPG W=W1PG L=L1PG M=1
XMI31 BT WL RTCOM VSS NPG W=W1PG L=L1PG M=1
XMI268 RT1 RB NET75 VSS NPD W=W1PD L=L1PD M=1
XMI272 RB WL RB1 VSS NPG W=W1PG L=L1PG M=1
XMI38 BT DEF RTCOM VSS N12_LP W=0.75U L=me84a03_LND M=2
XMI27 NET84 WL VSS VSS N12_LP W=0.5U L=0.075U M=1
XMPD31 RT2 RB NET84 VSS NPD W=W1PD L=L1PD M=1
XMI20 RB WL RB2 VSS NPG W=W1PG L=L1PG M=1
XMI26 NET75 WL VSS VSS N12_LP W=0.5U L=0.075U M=1
XMI34 RB2 WL VDD VSS NPG W=W1PG L=L1PG M=1
XMI33 RB1 WL VDD VSS NPG W=W1PG L=L1PG M=1
XMI35 RB1 DEF VDD VSS N12_LP W=0.75U L=me84a03_LND M=1
XMI36 RB2 DEF VDD VSS N12_LP W=0.75U L=me84a03_LND M=1
.ENDS me84a03_RAM6X_XPM_WK

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_INVM1                                                                *
* LAST TIME SAVED:  APR 02 16:33:39 2014                                      *
*******************************************************************************
.SUBCKT me84a03_INVM1 QN A LN=me84a03_LND LP=me84a03_LPD WN=me84a03_WND WP=me84a03_WPD
*.PININFO QN:O A:I
XMTP1 VDD A QN VDD P12_LP W=WP L=LP M=1
XMTN1 QN A VSS VSS NHVT12_LP W=WN L=LN M=1
.ENDS me84a03_INVM1

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RD_LC                                                                *
* LAST TIME SAVED:  MAY 08 15:22:56 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RD_LC WLB WLR LOG0 LOG1 VDDR WCLKRD WCLKRDB
*.PININFO WLB:O WLR:O LOG0:B LOG1:B VDDR:B WCLKRD:I WCLKRDB:I
XI9 WLR WLB VSS VDDR me84a03_INV_PG LN=me84a03_LD LP=me84a03_LD WN=5.0U WP=10.00U
XI10 WWRD LOG1 me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=2.5U WP=1.0U
XI24 WLB WLT me84a03_INVM1 LN=me84a03_LD LP=me84a03_LD WN=4.0U WP=8.0U
XMI6 VDD WCLKRD WLN VDD P12_LP W=3.52U L=me84a03_LD M=1
XI23 WLT WLN me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.3U WP=2.6U
XI3 WWRD WLN WCLKRD WCLKRDB me84a03_TGH WN=2.5U WP=1.0U
.ENDS me84a03_RD_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RW_SD_LC                                                             *
* LAST TIME SAVED:  MAY 08 15:22:56 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RW_SD_LC ACUTRK LOG0 LOG1 RBLRD RBLWR RWLDR RWLR VDDR WCLKRD WCLKRDB WLB
+ WRREF Z0 Z1 Z2 LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO ACUTRK:I LOG0:B LOG1:B RBLRD:B RBLWR:B RWLDR:I RWLR:O VDDR:B WCLKRD:B WCLKRDB:B
*.PININFO WLB:O WRREF:O Z0:I Z1:I Z2:I
XI4 RBLWR RB ACUTRK RWLDR WCLKRD me84a03_RAM6X_XPM_WK
XMI24 VDD RWLDR RBLRD VDD PHVT12_LP W=4.0U L=me84a03_LD M=1
XMI27 VDD BUF_WCLKRD NET089 VDD PHVT12_LP W=0.3U L=me84a03_LD M=1
XI523 BUF_WCLKRD NET094 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.25U WP=1.0U
XI9 WRREF RBB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.01U
XI39 NET094 WCLKRD me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XRD WLB RWLR LOG0 LOG1 VDDR WCLKRD WCLKRDB me84a03_RD_LC
XMI185 VDD LOG0 LOG1 VDD P12_LP W=2.4U L=me84a03_LD M=1
XMI32 RBLRD RWLDR NET34 VSS NPG W=W1PG L=L1PG M=4
XMI33 NET52 Z1 NET089 VSS NPD W=W1PD L=L1PD M=6
XMI34 RBLRD RWLDR NET52 VSS NPG W=W1PG L=L1PG M=6
XMI35 RBLRD RWLDR NET43 VSS NPG W=W1PG L=L1PG M=2
XMI36 NET43 LOG1 NET089 VSS NPD W=W1PD L=L1PD M=2
XMI31 NET34 Z0 NET089 VSS NPD W=W1PD L=L1PD M=4
XMI37 RBLRD RWLDR NET28 VSS NPG W=W1PG L=L1PG M=12
XMI38 NET28 Z2 NET089 VSS NPD W=W1PD L=L1PD M=12
XMI186 VSS LOG1 LOG0 VSS N12_LP W=0.6U L=me84a03_LD M=1
XMI25 NET089 BUF_WCLKRD VSS VSS N12_LP W=6.0U L=me84a03_LD M=1
XXRB RBB RB WCLKRD me84a03_ND2 LN1=me84a03_LND WN1=0.8U WN2=1.05U WP1=0.15U WP2=0.60U
.ENDS me84a03_RW_SD_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RW_LC                                                                *
* LAST TIME SAVED:  MAY 08 15:23:12 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RW_LC RWLL RWLR WRREF LOG0 LOG1 RBLRD RBLWR VDDL VDDR WCLKRD WCLKRDB
+ACUTRK RWLDR Z2 Z1 Z0 LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO RWLL:O RWLR:O WRREF:O LOG0:B LOG1:B RBLRD:B RBLWR:B VDDL:B VDDR:B WCLKRD:B
*.PININFO WCLKRDB:B ACUTRK:I RWLDR:I Z2:I Z1:I Z0:I
XI43 VDDL NET53 RWLL me84a03_RD_BUF
XI42 ACUTRK LOG0 LOG1 RBLRD RBLWR RWLDR RWLR VDDR WCLKRD WCLKRDB NET53 WRREF
+Z0 Z1 Z2 me84a03_RW_SD_LC
.ENDS me84a03_RW_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_STRAP2                                                               *
* LAST TIME SAVED:  MAY 08 15:23:14 2014                                      *
*******************************************************************************
.SUBCKT me84a03_STRAP2 LOG0
*.PININFO LOG0:B
XI3 LOG0 me84a03_STRAP
XI2 LOG0 me84a03_STRAP
.ENDS me84a03_STRAP2

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RAM_EDGE                                                             *
* LAST TIME SAVED:  MAY 08 15:22:53 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RAM_EDGE WL
*.PININFO WL:I
XMI268 VSS VSS VSS VSS NPD W=0.145U L=0.065U M=1
XMI0 VSS WL VSS VSS NPG W=0.095U L=0.075U M=1
.ENDS me84a03_RAM_EDGE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RAM_EDGE2                                                            *
* LAST TIME SAVED:  MAY 08 15:23:04 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RAM_EDGE2 WL0 WL1
*.PININFO WL0:I WL1:I
XI3 WL1 me84a03_RAM_EDGE
XI2 WL0 me84a03_RAM_EDGE
.ENDS me84a03_RAM_EDGE2

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_STRAP2_BOT                                                           *
* LAST TIME SAVED:  MAY 08 15:23:03 2014                                      *
*******************************************************************************
.SUBCKT me84a03_STRAP2_BOT LOG0
*.PININFO LOG0:B
XI3 LOG0 me84a03_STRAP_BOT
XI2 LOG0 me84a03_STRAP_BOT
.ENDS me84a03_STRAP2_BOT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RAM6X                                                                *
* LAST TIME SAVED:  MAY 08 15:23:00 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RAM6X BB BT NUBB NUBT RB RT SUP WL
*.PININFO BB:B BT:B NUBB:B NUBT:B RB:B RT:B SUP:I WL:I
XMI271 SUP RB RT VDD PPU W=W1PU L=L1PU M=1
XMI270 SUP RT RB VDD PPU W=W1PU L=L1PU M=1
XMI268 RT RB VSS VSS NPD W=W1PD L=L1PD M=1
XMI267 RB RT VSS VSS NPD W=W1PD L=L1PD M=1
XMI272 RB WL NUBB VSS NPG W=W1PG L=L1PG M=1
XMI269 NUBT WL RT VSS NPG W=W1PG L=L1PG M=1
.ENDS me84a03_RAM6X

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RAM6TSUP                                                             *
* LAST TIME SAVED:  MAY 08 15:22:55 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RAM6TSUP BB BT SUP WL
*.PININFO BB:B BT:B SUP:I WL:I
XI239 BB BT BB BT RB RT SUP WL me84a03_RAM6X
.ENDS me84a03_RAM6TSUP

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RAM6T                                                                *
* LAST TIME SAVED:  MAY 08 15:23:06 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RAM6T BB BT WL
*.PININFO BB:B BT:B WL:I
XI241 BB BT VDD WL me84a03_RAM6TSUP
.ENDS me84a03_RAM6T

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_BAR2                                                                 *
* LAST TIME SAVED:  MAY 08 15:23:00 2014                                      *
*******************************************************************************
.SUBCKT me84a03_BAR2 BB0 BB1 BT0 BT1 WL0 WL1
*.PININFO BB0:B BB1:B BT0:B BT1:B WL0:I WL1:I
XI328 BB1 BT1 WL1 me84a03_RAM6T
XI331 BB1 BT1 WL0 me84a03_RAM6T
XI273 BB0 BT0 WL1 me84a03_RAM6T
XI275 BB0 BT0 WL0 me84a03_RAM6T
.ENDS me84a03_BAR2

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_AR2_RT                                                               *
* LAST TIME SAVED:  MAY 08 15:22:58 2014                                      *
*******************************************************************************
.SUBCKT me84a03_AR2_RT BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 LOG0 WL7 WL6
+WL5 WL4 WL3 WL2 WL1 WL0
*.PININFO BB3:B BB2:B BB1:B BB0:B BT3:B BT2:B BT1:B BT0:B LOG0:B WL7:I
*.PININFO WL6:I WL5:I WL4:I WL3:I WL2:I WL1:I WL0:I
XI21 LOG0 me84a03_STRAP2
XI20 LOG0 me84a03_STRAP2
XI27 LOG0 me84a03_STRAP2
XI26 LOG0 me84a03_STRAP2
XI15 WL6 WL7 me84a03_RAM_EDGE2
XI14 WL4 WL5 me84a03_RAM_EDGE2
XI13 WL2 WL3 me84a03_RAM_EDGE2
XI12 WL0 WL1 me84a03_RAM_EDGE2
XI19 LOG0 me84a03_STRAP2_BOT
XI18 LOG0 me84a03_STRAP2_BOT
XI435 BB0 BB1 BT0 BT1 WL0 WL1 me84a03_BAR2
XI525 BB0 BB1 BT0 BT1 WL2 WL3 me84a03_BAR2
XI3 BB0 BB1 BT0 BT1 WL4 WL5 me84a03_BAR2
XI7 BB2 BB3 BT2 BT3 WL6 WL7 me84a03_BAR2
XI6 BB2 BB3 BT2 BT3 WL0 WL1 me84a03_BAR2
XI4 BB0 BB1 BT0 BT1 WL6 WL7 me84a03_BAR2
XI8 BB2 BB3 BT2 BT3 WL4 WL5 me84a03_BAR2
XI9 BB2 BB3 BT2 BT3 WL2 WL3 me84a03_BAR2
.ENDS me84a03_AR2_RT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_BWAR2_RET                                                            *
* LAST TIME SAVED:  MAY 08 15:23:08 2014                                      *
*******************************************************************************
.SUBCKT me84a03_BWAR2_RET BB0 BB1 BT0 BT1 LOG0 LOG1 RWL RWLD
*.PININFO BB0:B BB1:B BT0:B BT1:B LOG0:I LOG1:I RWL:I RWLD:I
XI275 BB0 BT0 NET2 NET24 NET21 NET26 VDD RWL me84a03_RAM6X
XI619 BB0 BT0 NET4 NET24 NET22 NET27 VDD RWLD me84a03_RAM6X
XI437 BB1 BT1 NET0 NET18 NET15 NET19 VDD LOG0 RWL me84a03_RAM6X_SPLIT
XI605 BB1 BT1 NET1 NET18 NET16 NET20 VDD LOG0 RWLD me84a03_RAM6X_SPLIT
XI15 LOG0 me84a03_STRAP2_BOT
.ENDS me84a03_BWAR2_RET

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_BWAR2                                                                *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_BWAR2 BB0 BB1 BT0 BT1 LOG0 LOG1 RWL RWLD
*.PININFO BB0:B BB1:B BT0:B BT1:B LOG0:I LOG1:I RWL:I RWLD:I
XI435 BB1 BT1 NET015 NET16 NET13 NET17 VDD RWL me84a03_RAM6X
XI607 BB1 BT1 NET051 NET16 NET14 NET18 VDD RWLD me84a03_RAM6X
XI275 BB0 BT0 NET31 NET22 NET19 NET24 VDD RWL me84a03_RAM6X
XI619 BB0 BT0 NET03 NET22 NET20 NET23 VDD RWLD me84a03_RAM6X
XI17 LOG0 me84a03_STRAP2_BOT
.ENDS me84a03_BWAR2

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WAR2_RT                                                              *
* LAST TIME SAVED:  MAY 08 15:23:14 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WAR2_RT BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 LOG0 LOG1 RWL
+RWLD
*.PININFO BB3:B BB2:B BB1:B BB0:B BT3:B BT2:B BT1:B BT0:B LOG0:B LOG1:B
*.PININFO RWL:I RWLD:I
XI2 LOG0 LOG0 me84a03_RAM_EDGE2
XI435 BB0 BB1 BT0 BT1 LOG0 LOG1 RWL RWLD me84a03_BWAR2_RET
XI464 BB2 BB3 BT2 BT3 LOG0 LOG1 LOG0 LOG0 me84a03_BWAR2
.ENDS me84a03_WAR2_RT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_AR2_LT                                                               *
* LAST TIME SAVED:  MAY 08 15:22:55 2014                                      *
*******************************************************************************
.SUBCKT me84a03_AR2_LT BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 LOG0 WL7 WL6
+WL5 WL4 WL3 WL2 WL1 WL0
*.PININFO BB3:B BB2:B BB1:B BB0:B BT3:B BT2:B BT1:B BT0:B LOG0:B WL7:I
*.PININFO WL6:I WL5:I WL4:I WL3:I WL2:I WL1:I WL0:I
XI21 LOG0 me84a03_STRAP2
XI20 LOG0 me84a03_STRAP2
XI27 LOG0 me84a03_STRAP2
XI26 LOG0 me84a03_STRAP2
XI31 WL0 WL1 me84a03_RAM_EDGE2
XI30 WL2 WL3 me84a03_RAM_EDGE2
XI29 WL4 WL5 me84a03_RAM_EDGE2
XI28 WL6 WL7 me84a03_RAM_EDGE2
XI15 WL6 WL7 me84a03_RAM_EDGE2
XI14 WL4 WL5 me84a03_RAM_EDGE2
XI13 WL2 WL3 me84a03_RAM_EDGE2
XI12 WL0 WL1 me84a03_RAM_EDGE2
XI19 LOG0 me84a03_STRAP2_BOT
XI18 LOG0 me84a03_STRAP2_BOT
XI435 BB0 BB1 BT0 BT1 WL0 WL1 me84a03_BAR2
XI525 BB0 BB1 BT0 BT1 WL2 WL3 me84a03_BAR2
XI3 BB0 BB1 BT0 BT1 WL4 WL5 me84a03_BAR2
XI7 BB2 BB3 BT2 BT3 WL6 WL7 me84a03_BAR2
XI6 BB2 BB3 BT2 BT3 WL0 WL1 me84a03_BAR2
XI4 BB0 BB1 BT0 BT1 WL6 WL7 me84a03_BAR2
XI8 BB2 BB3 BT2 BT3 WL4 WL5 me84a03_BAR2
XI9 BB2 BB3 BT2 BT3 WL2 WL3 me84a03_BAR2
.ENDS me84a03_AR2_LT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WAR2_LT                                                              *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WAR2_LT BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 LOG0 LOG1 RWL
+RWLD
*.PININFO BB3:B BB2:B BB1:B BB0:B BT3:B BT2:B BT1:B BT0:B LOG0:B LOG1:B
*.PININFO RWL:I RWLD:I
XI11 RWLD RWL me84a03_RAM_EDGE2
XI2 LOG0 LOG0 me84a03_RAM_EDGE2
XI435 BB0 BB1 BT0 BT1 LOG0 LOG1 RWL RWLD me84a03_BWAR2_RET
XI464 BB2 BB3 BT2 BT3 LOG0 LOG1 LOG0 LOG0 me84a03_BWAR2
.ENDS me84a03_WAR2_LT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM2_LITE_LC                                                        *
* LAST TIME SAVED:  MAY 08 15:23:12 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM2_LITE_LC BB0 BB1 BT0 BT1 CCRD DA DCLKB LOG0 LOG1 LWE0
+LWE1 PCB0 PCB1 Q SAEB LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BT0:B BT1:B CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE0:I
*.PININFO LWE1:I PCB0:B PCB1:B Q:O SAEB:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET028 LWE1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET029 CCRD me84a03_LSA1
XI31 NET21 Q DA LQT me84a03_DO2_LITE_LC
DI34 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
XXMX BB1 BB0 BT1 BT0 RDB RDT WRB WRT PCB1 PCB0 me84a03_CMUX2
XXDI WRB WRT DCLKB NET21 LWE0 me84a03_WRDRV2_LITE_LC
XI38 NET029 SAEB NET028 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM2_LITE_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CBUF_LITE_LC                                                         *
* LAST TIME SAVED:  MAY 08 15:23:08 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CBUF_LITE_LC CCRDL CSHARE DCLKBL FLOATI LA0QB LA0QT LA1QB LWEI LWEL
+PRCHBL0 PRCHBL1 PRCHBL2 PRCHBL3 PRCLK SAEBL SAEBRT SAOFF
*.PININFO CCRDL:O CSHARE:I DCLKBL:O FLOATI:I LA0QB:I LA0QT:I LA1QB:I LWEI:I LWEL:O
*.PININFO PRCHBL0:O PRCHBL1:O PRCHBL2:O PRCHBL3:O PRCLK:I SAEBL:O SAEBRT:I SAOFF:I
XI131 PRCHBL3 LA0QT CSHARE PRCLK me84a03_DEC2TO1_LC
XI130 PRCHBL2 LA0QB CSHARE PRCLK me84a03_DEC2TO1_LC
XI129 PRCHBL1 LA0QT LA1QB PRCLK me84a03_DEC2TO1_LC
XI128 PRCHBL0 LA0QB LA1QB PRCLK me84a03_DEC2TO1_LC
XI54 LWEL LWEI me84a03_INV LN=me84a03_LD LP=0.07U WN=3U WP=6.96U
XI0 CCRDL SAOFF me84a03_INV LN=me84a03_LD LP=0.07U WN=3U WP=6.96U
XI55 DCLKBL FLOATI me84a03_INV LN=0.07U LP=me84a03_LD WN=3.48U WP=6U
XI23 SAEBL SAEBRT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=8.8U WP=5.2U
.ENDS me84a03_CBUF_LITE_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_PR16B_LC                                                             *
* LAST TIME SAVED:  MAY 08 15:22:51 2014                                      *
*******************************************************************************
.SUBCKT me84a03_PR16B_LC QB15 QB14 QB13 QB12 QB11 QB10 QB9 QB8 QB7
+QB6 QB5 QB4 QB3 QB2 QB1 QB0 A3 A2 A1 A0 CB CT LN1=me84a03_LND
+LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO QB15:O QB14:O QB13:O QB12:O QB11:O QB10:O QB9:O QB8:O QB7:O
*.PININFO QB6:O QB5:O QB4:O QB3:O QB2:O QB1:O QB0:O A3:I A2:I A1:I
*.PININFO A0:I CB:I CT:I
XI390 LA3QB LA3QT A3 CB CT me84a03_ADRLAT_LC
XI216 LA2QB LA2QT A2 CB CT me84a03_ADRLAT_LC
XI168 LA1QB LA1QT A1 CB CT me84a03_ADRLAT_LC
XI165 LA0QB LA0QT A0 CB CT me84a03_ADRLAT_LC
XI335 QB8 LA0QB LA1QB LA2QB LA3QT me84a03_DEC4TO1B_LC
XI336 QB14 LA0QB LA1QT LA2QT LA3QT me84a03_DEC4TO1B_LC
XI337 QB12 LA0QB LA1QB LA2QT LA3QT me84a03_DEC4TO1B_LC
XI339 QB10 LA0QB LA1QT LA2QB LA3QT me84a03_DEC4TO1B_LC
XI340 QB9 LA0QT LA1QB LA2QB LA3QT me84a03_DEC4TO1B_LC
XI345 QB15 LA0QT LA1QT LA2QT LA3QT me84a03_DEC4TO1B_LC
XI346 QB13 LA0QT LA1QB LA2QT LA3QT me84a03_DEC4TO1B_LC
XI347 QB11 LA0QT LA1QT LA2QB LA3QT me84a03_DEC4TO1B_LC
XI131 QB3 LA0QT LA1QT LA2QB LA3QB me84a03_DEC4TO1B_LC
XI207 QB5 LA0QT LA1QB LA2QT LA3QB me84a03_DEC4TO1B_LC
XI205 QB7 LA0QT LA1QT LA2QT LA3QB me84a03_DEC4TO1B_LC
XI129 QB1 LA0QT LA1QB LA2QB LA3QB me84a03_DEC4TO1B_LC
XI130 QB2 LA0QB LA1QT LA2QB LA3QB me84a03_DEC4TO1B_LC
XI200 QB4 LA0QB LA1QB LA2QT LA3QB me84a03_DEC4TO1B_LC
XI206 QB6 LA0QB LA1QT LA2QT LA3QB me84a03_DEC4TO1B_LC
XI307 QB0 LA0QB LA1QB LA2QB LA3QB me84a03_DEC4TO1B_LC
.ENDS me84a03_PR16B_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ADRGEN_LC                                                            *
* LAST TIME SAVED:  MAY 08 15:23:05 2014                                      *
*******************************************************************************
.SUBCKT me84a03_ADRGEN_LC LYA0QB LYA0QT LYA1QB LYA1QT PAB7 PAB6 PAB5 PAB4 PAB3
+ PAB2 PAB1 PAB0 PBB15 PBB14 PBB13 PBB12 PBB11 PBB10 PBB9
+PBB8 PBB7 PBB6 PBB5 PBB4 PBB3 PBB2 PBB1 PBB0 PRCHBR3
+PRCHBR2 PRCHBR1 PRCHBR0 CSHARE LCLKB LCLKT PRCLK QXA6 QXA5 QXA4
+QXA3 QXA2 QXA1 QXA0 QYA1 QYA0 LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO LYA0QB:O LYA0QT:O LYA1QB:O LYA1QT:O PAB7:O PAB6:O PAB5:O PAB4:O PAB3:O
*.PININFO PAB2:O PAB1:O PAB0:O PBB15:O PBB14:O PBB13:O PBB12:O PBB11:O
*.PININFO PBB10:O PBB9:O PBB8:O PBB7:O PBB6:O PBB5:O PBB4:O PBB3:O
*.PININFO PBB2:O PBB1:O PBB0:O PRCHBR3:O PRCHBR2:O PRCHBR1:O PRCHBR0:O
*.PININFO CSHARE:I LCLKB:I LCLKT:I PRCLK:I QXA6:I QXA5:I QXA4:I QXA3:I QXA2:I
*.PININFO QXA1:I QXA0:I QYA1:I QYA0:I
XXB PBB15 PBB14 PBB13 PBB12 PBB11 PBB10 PBB9 PBB8 PBB7 PBB6
+PBB5 PBB4 PBB3 PBB2 PBB1 PBB0 QXA6 QXA5 QXA4 QXA3 LCLKB
+LCLKT me84a03_PR16B_LC
XIXA RPAB1 RPAB0 PAB7 PAB6 PAB5 PAB4 PAB3 PAB2 PAB1 PAB0
+QXA2 QXA1 QXA0 LCLKB LCLKT me84a03_PR8B_LC
XXYM LYA0QB LYA0QT LYA1QB LYA1QT PRCHBR3 PRCHBR2 PRCHBR1 PRCHBR0 QYA0
+QYA1 LCLKB CSHARE LCLKT PRCLK me84a03_PR4_LC
.ENDS me84a03_ADRGEN_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CENTER_SD_LITE_LC                                                    *
* LAST TIME SAVED:  MAY 08 15:22:50 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CENTER_SD_LITE_LC ACUTRK CCOR CCRDR CCWR CLK DCLKBR FLOATI LOG0 LOG1
+LWEI LWER MCLK ME MERDA0 MERDA1 PARDB0 PARDB1 PARDB2 PARDB3 PARDB4
+PARDB5 PARDB6 PARDB7 PBRDB0 PBRDB1 PBRDB10 PBRDB11 PBRDB12
+PBRDB13 PBRDB14 PBRDB15 PBRDB2 PBRDB3 PBRDB4 PBRDB5 PBRDB6
+PBRDB7 PBRDB8 PBRDB9 PCBR0 PCBR1 PCBR2 PCBR3 PRCLKRD PRM00
+PRM01 PRM02 PRM03 PRM04 PRM10 PRM11 PRM12 PRM13 PRM14 RCSHARE
+ RDOFF RLYA0QB RLYA0QT RLYA1QB RLYA1QT RMDEF0 RMDEF1 RMDEF2 RMEN RMENB
+RMENI0 RMENI1 RMEXT0 RMEXT1 RMEXT2 RMEXT3 RMFAST0 RMFAST1
+RMFAST2 RMSLOW0 RMSLOW1 RMSLOW2 RST RW_RBL SAEBRT SAOFF SMERD STCLK
+STCLKWR SWE T1B TEST1 WCLKRD0 WCLKRD1 WCLKRDB0 WCLKRDB1 WE WEA0 WEA1
+XARD0 XARD1 XARD2 XARD3 XARD4 XARD5 XARD6 YARD0 YARD1 Z0
+Z0B Z1 Z2 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LN3=me84a03_LND
+LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD LP3=me84a03_LPD
*.PININFO ACUTRK:O CCOR:O CCRDR:O CCWR:O CLK:I DCLKBR:O FLOATI:O LOG0:B LOG1:B LWEI:O
*.PININFO LWER:O MCLK:O ME:I MERDA0:O MERDA1:O PARDB0:O PARDB1:O PARDB2:O PARDB3:O
*.PININFO PARDB4:O PARDB5:O PARDB6:O PARDB7:O PBRDB0:O PBRDB1:O PBRDB10:O
*.PININFO PBRDB11:O PBRDB12:O PBRDB13:O PBRDB14:O PBRDB15:O PBRDB2:O
*.PININFO PBRDB3:O PBRDB4:O PBRDB5:O PBRDB6:O PBRDB7:O PBRDB8:O PBRDB9:O
*.PININFO PCBR0:O PCBR1:O PCBR2:O PCBR3:O PRCLKRD:O PRM00:B PRM01:B PRM02:B
*.PININFO PRM03:B PRM04:B PRM10:B PRM11:B PRM12:B PRM13:B PRM14:B RCSHARE:I
*.PININFO RDOFF:O RLYA0QB:O RLYA0QT:O RLYA1QB:O RLYA1QT:O RMDEF0:I RMDEF1:I RMDEF2:I
*.PININFO RMEN:I RMENB:O RMENI0:I RMENI1:I RMEXT0:I RMEXT1:I RMEXT2:I RMEXT3:I
*.PININFO RMFAST0:I RMFAST1:I RMFAST2:I RMSLOW0:I RMSLOW1:I RMSLOW2:I RST:I
*.PININFO RW_RBL:O SAEBRT:B SAOFF:O SMERD:I STCLK:I STCLKWR:I SWE:I T1B:O TEST1:I
*.PININFO WCLKRD0:O WCLKRD1:O WCLKRDB0:O WCLKRDB1:O WE:I WEA0:O WEA1:O XARD0:I
*.PININFO XARD1:I XARD2:I XARD3:I XARD4:I XARD5:I XARD6:I YARD0:I YARD1:I
*.PININFO Z0:O Z0B:O Z1:O Z2:O
XI37 LOG0 me84a03_LOG
XI60 ACUTRK RMENB RW_RBL Z0B Z2 Z1 Z0 PRM04 PRM03 PRM02 PRM01
+PRM00 PRM14 PRM13 PRM12 PRM11 PRM10 RMDEF2 RMDEF1 RMDEF0 RMEN
+RMENI1 RMENI0 RMEXT3 RMEXT2 RMEXT1 RMEXT0 RMFAST2 RMFAST1
+RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 me84a03_RMMX_LC
XXCENRD CCOR CCRDR CCWR DCLKBR FLOATI LCLKBRD LCLKTRD PRCLKRD RDOFF SAOFF
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 RFLOAT CLK LME LWE MCLK METRD RST
+STCLK STCLKWR T1B me84a03_CENRD_LITE_LC
XMI46 VDD LOG0 LOG1 VDD P12_LP W=6.0U L=me84a03_LD M=1
XXR LME LWE LWEI LWER MCLK MERDA0 MERDA1 METRD T1B WEA0 WEA1 LCLKBRD CLK LCLKTRD
+ ME SMERD SWE TEST1 WE me84a03_CTRL_LITE_LC
XXADRRDMUX QXARD6 QXARD5 QXARD4 QXARD3 QXARD2 QXARD1 QXARD0
+QYARD1 QYARD0 XARD6 XARD5 XARD4 XARD3 XARD2 XARD1 XARD0
+YARD1 YARD0 me84a03_ADRMUX_LITE
XXADRD RLYA0QB RLYA0QT RLYA1QB RLYA1QT PARDB7 PARDB6 PARDB5 PARDB4
+PARDB3 PARDB2 PARDB1 PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12
+PBRDB11 PBRDB10 PBRDB9 PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4
+PBRDB3 PBRDB2 PBRDB1 PBRDB0 PCBR3 PCBR2 PCBR1 PCBR0 RCSHARE
+LCLKBRD LCLKTRD PRCLKRD QXARD6 QXARD5 QXARD4 QXARD3 QXARD2 QXARD1
+QXARD0 QYARD1 QYARD0 me84a03_ADRGEN_LC
XMI45 VSS LOG1 LOG0 VSS N12_LP W=6.0U L=me84a03_LD M=1
.ENDS me84a03_CENTER_SD_LITE_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CENTER_LITE_LC                                                       *
* LAST TIME SAVED:  MAY 08 15:22:53 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CENTER_LITE_LC ACUTRK CCOR CCRDL CCRDR CCWR DCLKBL DCLKBR LWEL LWER MCLK
+ MERDA0 MERDA1 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1
+PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9
+PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1
+PBRDB0 PCBL3 PCBL2 PCBL1 PCBL0 PCBR3 PCBR2 PCBR1 PCBR0 RDOFF
+RLYA1QB RLYA1QT RMENB RW_RBL SAEBL SAOFF T1B WCLKRD1 WCLKRD0 WCLKRDB1
+WCLKRDB0 WEA0 WEA1 Z0B Z2 Z1 Z0 LOG0 LOG1 PRM04 PRM03 PRM02
+PRM01 PRM00 PRM14 PRM13 PRM12 PRM11 PRM10 SAEBRT CLK ME RCSHARE
+RMDEF2 RMDEF1 RMDEF0 RMEN RMENI1 RMENI0 RMEXT3 RMEXT2 RMEXT1
+RMEXT0 RMFAST2 RMFAST1 RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 RST SMERD
+STCLK STCLKWR SWE TEST1 WE XARD6 XARD5 XARD4 XARD3 XARD2 XARD1
+XARD0 YARD1 YARD0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND
+LN3=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
+LP3=me84a03_LPD
*.PININFO ACUTRK:O CCOR:O CCRDL:O CCRDR:O CCWR:O DCLKBL:O DCLKBR:O LWEL:O LWER:O MCLK:O
*.PININFO MERDA0:O MERDA1:O PARDB7:O PARDB6:O PARDB5:O PARDB4:O PARDB3:O
*.PININFO PARDB2:O PARDB1:O PARDB0:O PBRDB15:O PBRDB14:O PBRDB13:O PBRDB12:O
*.PININFO PBRDB11:O PBRDB10:O PBRDB9:O PBRDB8:O PBRDB7:O PBRDB6:O PBRDB5:O
*.PININFO PBRDB4:O PBRDB3:O PBRDB2:O PBRDB1:O PBRDB0:O PCBL3:O PCBL2:O
*.PININFO PCBL1:O PCBL0:O PCBR3:O PCBR2:O PCBR1:O PCBR0:O RDOFF:O RLYA1QB:O
*.PININFO RLYA1QT:O RMENB:O RW_RBL:O SAEBL:O SAOFF:O T1B:O WCLKRD1:O WCLKRD0:O
*.PININFO WCLKRDB1:O WCLKRDB0:O WEA0:O WEA1:O Z0B:O Z2:O Z1:O Z0:O LOG0:B LOG1:B
*.PININFO PRM04:B PRM03:B PRM02:B PRM01:B PRM00:B PRM14:B PRM13:B PRM12:B
*.PININFO PRM11:B PRM10:B SAEBRT:B CLK:I ME:I RCSHARE:I RMDEF2:I RMDEF1:I
*.PININFO RMDEF0:I RMEN:I RMENI1:I RMENI0:I RMEXT3:I RMEXT2:I RMEXT1:I
*.PININFO RMEXT0:I RMFAST2:I RMFAST1:I RMFAST0:I RMSLOW2:I RMSLOW1:I
*.PININFO RMSLOW0:I RST:I SMERD:I STCLK:I STCLKWR:I SWE:I TEST1:I WE:I XARD6:I
*.PININFO XARD5:I XARD4:I XARD3:I XARD2:I XARD1:I XARD0:I YARD1:I YARD0:I
XI62 CCRDL RCSHARE DCLKBL FLOATI YA0QB YA0QT RLYA1QB LWEI LWEL PCBL0 PCBL1
+PCBL2 PCBL3 PRCLK SAEBL SAEBRT SAOFF me84a03_CBUF_LITE_LC
XXC ACUTRK CCOR CCRDR CCWR CLK DCLKBR FLOATI LOG0 LOG1 LWEI LWER MCLK ME MERDA0
+MERDA1 PARDB0 PARDB1 PARDB2 PARDB3 PARDB4 PARDB5 PARDB6 PARDB7
+PBRDB0 PBRDB1 PBRDB10 PBRDB11 PBRDB12 PBRDB13 PBRDB14 PBRDB15
+PBRDB2 PBRDB3 PBRDB4 PBRDB5 PBRDB6 PBRDB7 PBRDB8 PBRDB9 PCBR0
+PCBR1 PCBR2 PCBR3 PRCLK PRM00 PRM01 PRM02 PRM03 PRM04 PRM10
+PRM11 PRM12 PRM13 PRM14 RCSHARE RDOFF YA0QB YA0QT RLYA1QB RLYA1QT
+RMDEF0 RMDEF1 RMDEF2 RMEN RMENB RMENI0 RMENI1 RMEXT0 RMEXT1
+RMEXT2 RMEXT3 RMFAST0 RMFAST1 RMFAST2 RMSLOW0 RMSLOW1 RMSLOW2
+RST RW_RBL SAEBRT SAOFF SMERD STCLK STCLKWR SWE T1B TEST1 WCLKRD0 WCLKRD1
+WCLKRDB0 WCLKRDB1 WE WEA0 WEA1 XARD0 XARD1 XARD2 XARD3 XARD4
+XARD5 XARD6 YARD0 YARD1 Z0 Z0B Z1 Z2 me84a03_CENTER_SD_LITE_LC
.ENDS me84a03_CENTER_LITE_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_XDEC_PG_BUF                                                          *
* LAST TIME SAVED:  MAY 08 15:23:12 2014                                      *
*******************************************************************************
.SUBCKT me84a03_XDEC_PG_BUF VDDL WLB
*.PININFO VDDL:B WLB:I
XMI26 VDD WLB VDDL VDD P12_LP W=10U L=me84a03_LD M=1
.ENDS me84a03_XDEC_PG_BUF

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_XDEC_BUF                                                             *
* LAST TIME SAVED:  MAY 08 15:23:10 2014                                      *
*******************************************************************************
.SUBCKT me84a03_XDEC_BUF WLL VDDL WLB
*.PININFO WLL:O VDDL:I WLB:I
XI364 WLL WLB VSS VDDL me84a03_INV_PG LN=me84a03_LD LP=me84a03_LD WN=5U WP=10U
.ENDS me84a03_XDEC_BUF

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X2DEC_BUF                                                            *
* LAST TIME SAVED:  MAY 08 15:23:06 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X2DEC_BUF VDDL WLB0 WLB1 WLL0 WLL1
*.PININFO VDDL:I WLB0:I WLB1:I WLL0:O WLL1:O
XXDECFF WLL1 VDDL WLB1 me84a03_XDEC_BUF
XXDEC00 WLL0 VDDL WLB0 me84a03_XDEC_BUF
.ENDS me84a03_X2DEC_BUF

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X8DEC_BUF_LC                                                         *
* LAST TIME SAVED:  MAY 08 15:22:56 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X8DEC_BUF_LC WLL7 WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0
+VDDL RDOFFI1 RDOFFI0 WLB7 WLB6 WLB5 WLB4 WLB3 WLB2 WLB1
+WLB0
*.PININFO WLL7:O WLL6:O WLL5:O WLL4:O WLL3:O WLL2:O WLL1:O WLL0:O VDDL:B
*.PININFO RDOFFI1:I RDOFFI0:I WLB7:I WLB6:I WLB5:I WLB4:I WLB3:I WLB2:I
*.PININFO WLB1:I WLB0:I
XI15 VDDL RDOFFI1 me84a03_XDEC_PG_BUF
XI13 VDDL RDOFFI0 me84a03_XDEC_PG_BUF
XX2DEC01 VDDL WLB2 WLB3 WLL2 WLL3 me84a03_X2DEC_BUF
XX2DEC00 VDDL WLB0 WLB1 WLL0 WLL1 me84a03_X2DEC_BUF
XX2DEC02 VDDL WLB4 WLB5 WLL4 WLL5 me84a03_X2DEC_BUF
XX2DECFF VDDL WLB6 WLB7 WLL6 WLL7 me84a03_X2DEC_BUF
.ENDS me84a03_X8DEC_BUF_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_XDEC_SD_PG                                                           *
* LAST TIME SAVED:  MAY 08 15:23:06 2014                                      *
*******************************************************************************
.SUBCKT me84a03_XDEC_SD_PG RDOFF VDDR WLB WRREF
*.PININFO RDOFF:I VDDR:B WLB:O WRREF:B
XMI26 VDD WLB VDDR VDD P12_LP W=10U L=me84a03_LD M=1
XI24 WLB WLT me84a03_INVM1 LN=me84a03_LD LP=me84a03_LD WN=4.0U WP=4.0U
XI23 WLT RDOFF me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1U WP=1U
.ENDS me84a03_XDEC_SD_PG

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_NR2PAH                                                               *
* LAST TIME SAVED:  APR 02 12:28:18 2014                                      *
*******************************************************************************
.SUBCKT me84a03_NR2PAH Z A B LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD
+LP2=me84a03_LPD WN1=me84a03_WND WN2=me84a03_WND WP1=me84a03_WPD
+WP2=me84a03_WPD
*.PININFO Z:O A:I B:I
XMTN1 Z B VSS VSS NHVT12_LP W=WN1 L=LN1 M=1
XMTN2 Z A VSS VSS NHVT12_LP W=WN2 L=LN2 M=1
XMTP1 NET33 B Z VDD PHVT12_LP W=WP1 L=LP1 M=1
XMTP2 VDD A NET33 VDD PHVT12_LP W=WP2 L=LP2 M=1
XMI1 VDD A N2 VDD PHVT12_LP W=WP2 L=LP2 M=1
XMI0 N2 B Z VDD PHVT12_LP W=WP1 L=LP1 M=1
.ENDS me84a03_NR2PAH

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_XDEC_SD_LC                                                           *
* LAST TIME SAVED:  MAY 08 15:23:13 2014                                      *
*******************************************************************************
.SUBCKT me84a03_XDEC_SD_LC WLB WLR WRREF ARD BRD VDDR WCLKRD WCLKRDB LN=me84a03_LND LP=me84a03_LPD
*.PININFO WLB:O WLR:O WRREF:B ARD:I BRD:I VDDR:I WCLKRD:I WCLKRDB:I
XI23 WLT WLN me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.3U WP=2.6U
XI352 ABRD ARD BRD me84a03_NR2PAH LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD WN1=0.38U WN2=0.38U
+WP1=0.3U WP2=0.3U
XI15 WWRD WLN WCLKRD WCLKRDB me84a03_TG WN=1.5U WP=1.0U
XI364 WLR WLB VSS VDDR me84a03_INV_PG LN=me84a03_LD LP=me84a03_LD WN=5U WP=10U
XI24 WLB WLT me84a03_INVM1 LN=me84a03_LD LP=me84a03_LD WN=4.0U WP=8.0U
XMI500 VDD WCLKRD WLN VDD P12_LP W=1.8U L=me84a03_LD M=1
XI233 WWRD ABRD me84a03_INVH LN=me84a03_LD LP=me84a03_LD WN=2.0U WP=1.5U
.ENDS me84a03_XDEC_SD_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X2DEC_SD_LC                                                          *
* LAST TIME SAVED:  MAY 08 15:23:05 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X2DEC_SD_LC ARD0 ARD1 BRD VDDR WCLKRD WCLKRDB0 WCLKRDB1 WLB0
+WLB1 WLR0 WLR1 WRREF LN=me84a03_LND LP=me84a03_LPD
*.PININFO ARD0:I ARD1:I BRD:I VDDR:I WCLKRD:I WCLKRDB0:I WCLKRDB1:I WLB0:O
*.PININFO WLB1:O WLR0:O WLR1:O WRREF:B
XXDECFF WLB1 WLR1 WRREF ARD1 BRD VDDR WCLKRD WCLKRDB1 me84a03_XDEC_SD_LC
XXDEC00 WLB0 WLR0 WRREF ARD0 BRD VDDR WCLKRD WCLKRDB0 me84a03_XDEC_SD_LC
.ENDS me84a03_X2DEC_SD_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X8DEC_SD_LC                                                          *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X8DEC_SD_LC RDOFFI1 RDOFFI0 WLB7 WLB6 WLB5 WLB4 WLB3
+WLB2 WLB1 WLB0 WLR7 WLR6 WLR5 WLR4 WLR3 WLR2 WLR1 WLR0
+ACUTRK VDDR WRREF Z2 Z1 Z0 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3
+PARDB2 PARDB1 PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11
+PBRDB10 PBRDB9 PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3
+PBRDB2 PBRDB1 PBRDB0 RDOFF WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 LN=me84a03_LND
+ LP=me84a03_LPD
*.PININFO RDOFFI1:O RDOFFI0:O WLB7:O WLB6:O WLB5:O WLB4:O WLB3:O WLB2:O
*.PININFO WLB1:O WLB0:O WLR7:O WLR6:O WLR5:O WLR4:O WLR3:O WLR2:O WLR1:O
*.PININFO WLR0:O ACUTRK:B VDDR:B WRREF:B Z2:B Z1:B Z0:B PARDB7:I PARDB6:I
*.PININFO PARDB5:I PARDB4:I PARDB3:I PARDB2:I PARDB1:I PARDB0:I PBRDB15:I
*.PININFO PBRDB14:I PBRDB13:I PBRDB12:I PBRDB11:I PBRDB10:I PBRDB9:I
*.PININFO PBRDB8:I PBRDB7:I PBRDB6:I PBRDB5:I PBRDB4:I PBRDB3:I PBRDB2:I
*.PININFO PBRDB1:I PBRDB0:I RDOFF:I WCLKRD1:I WCLKRD0:I WCLKRDB1:I WCLKRDB0:I
XI15 RDOFF VDDR RDOFFI1 WRREF me84a03_XDEC_SD_PG
XI13 RDOFF VDDR RDOFFI0 WRREF me84a03_XDEC_SD_PG
XX2DEC01 PARDB2 PARDB3 PBRDB0 VDDR WCLKRD0 WCLKRDB0 WCLKRDB1 WLB2
+WLB3 WLR2 WLR3 WRREF me84a03_X2DEC_SD_LC
XX2DEC00 PARDB0 PARDB1 PBRDB0 VDDR WCLKRD0 WCLKRDB0 WCLKRDB1 WLB0
+WLB1 WLR0 WLR1 WRREF me84a03_X2DEC_SD_LC
XX2DEC02 PARDB4 PARDB5 PBRDB0 VDDR WCLKRD1 WCLKRDB0 WCLKRDB1 WLB4
+WLB5 WLR4 WLR5 WRREF me84a03_X2DEC_SD_LC
XX2DECFF PARDB6 PARDB7 PBRDB0 VDDR WCLKRD1 WCLKRDB0 WCLKRDB1 WLB6
+WLB7 WLR6 WLR7 WRREF me84a03_X2DEC_SD_LC
.ENDS me84a03_X8DEC_SD_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X8DEC_LC                                                             *
* LAST TIME SAVED:  MAY 08 15:22:58 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X8DEC_LC WLL7 WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 WLR7
+WLR6 WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 ACUTRK VDDL VDDR WRREF Z2
+Z1 Z0 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1
+PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9
+PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1
+PBRDB0 RDOFF WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 LN=me84a03_LND LP=me84a03_LPD
*.PININFO WLL7:O WLL6:O WLL5:O WLL4:O WLL3:O WLL2:O WLL1:O WLL0:O WLR7:O
*.PININFO WLR6:O WLR5:O WLR4:O WLR3:O WLR2:O WLR1:O WLR0:O ACUTRK:B VDDL:B
*.PININFO VDDR:B WRREF:B Z2:B Z1:B Z0:B PARDB7:I PARDB6:I PARDB5:I PARDB4:I
*.PININFO PARDB3:I PARDB2:I PARDB1:I PARDB0:I PBRDB15:I PBRDB14:I PBRDB13:I
*.PININFO PBRDB12:I PBRDB11:I PBRDB10:I PBRDB9:I PBRDB8:I PBRDB7:I PBRDB6:I
*.PININFO PBRDB5:I PBRDB4:I PBRDB3:I PBRDB2:I PBRDB1:I PBRDB0:I RDOFF:I
*.PININFO WCLKRD1:I WCLKRD0:I WCLKRDB1:I WCLKRDB0:I
XI20 WLL7 WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 VDDL NET0261
+NET0260 NET467 NET466 NET465 NET464 NET463 NET462 NET461
+NET460 me84a03_X8DEC_BUF_LC
XI19 NET0261 NET0260 NET467 NET466 NET465 NET464 NET463 NET462
+NET461 NET460 WLR7 WLR6 WLR5 WLR4 WLR3 WLR2 WLR1 WLR0
+ACUTRK VDDR WRREF Z2 Z1 Z0 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3
+PARDB2 PARDB1 PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11
+PBRDB10 PBRDB9 PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3
+PBRDB2 PBRDB1 PBRDB0 RDOFF WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0
+me84a03_X8DEC_SD_LC
.ENDS me84a03_X8DEC_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X1P11CM2_LITE_LC                                                     *
* LAST TIME SAVED:  MAY 08 15:22:57 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X1P11CM2_LITE_LC Q3 Q2 Q1 Q0 CLK D3 D2 D1 D0 ME RM3
+RM2 RM1 RM0 RMDEF2 RMDEF1 RMDEF0 RMEN RMFAST2 RMFAST1 RMFAST0
+ RMSLOW2 RMSLOW1 RMSLOW0 RST TEST1 WE XA6 XA5 XA4 XA3 XA2 XA1
+ XA0 YA1 YA0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LN3=me84a03_LND
+LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD LP3=me84a03_LPD
*.PININFO Q3:O Q2:O Q1:O Q0:O CLK:I D3:I D2:I D1:I D0:I ME:I RM3:I
*.PININFO RM2:I RM1:I RM0:I RMDEF2:I RMDEF1:I RMDEF0:I RMEN:I RMFAST2:I
*.PININFO RMFAST1:I RMFAST0:I RMSLOW2:I RMSLOW1:I RMSLOW0:I RST:I TEST1:I WE:I
*.PININFO XA6:I XA5:I XA4:I XA3:I XA2:I XA1:I XA0:I YA1:I YA0:I
XI19 LOG0 LOG1 me84a03_CAP_RT
XI20 LOG0 LOG1 me84a03_CAP_LT
XXHSLREF LOG0 RBLRD RBLWR WLR7 WLR6 WLR5 WLR4 WLR3 WLR2 WLR1
+WLR0 me84a03_HSLREF
XXWARREF LOG0 LOG1 RBLRD RBLWR RWLR RWLR me84a03_WARREF
XXRW RWLL RWLR WRREF LOG0 LOG1 RBLRD RBLWR NET110 NET109 WCLKRD0 WCLKRDB0
+ACUTRK RWLR Z2 Z1 Z0 me84a03_RW_LC
XXARRR BBR3 BBR2 BBR1 BBR0 BTR3 BTR2 BTR1 BTR0 LOG0 WLR7
+WLR6 WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 me84a03_AR2_RT
XXWAR2R BBR3 BBR2 BBR1 BBR0 BTR3 BTR2 BTR1 BTR0 LOG0 LOG1 RWLR
+RWLR me84a03_WAR2_RT
XXARRL BBL3 BBL2 BBL1 BBL0 BTL3 BTL2 BTL1 BTL0 LOG0 WLL7
+WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 me84a03_AR2_LT
XXWAR2L BBL3 BBL2 BBL1 BBL0 BTL3 BTL2 BTL1 BTL0 LOG0 LOG1 RWLL
+RWLL me84a03_WAR2_LT
XXRIO CCOR CCRD CCWR DCLKBR LOG0 LOG1 LWER MCLK PRCHRDBR0 PRCHRDBR1
+PRCHRDBR2 PRCHRDBR3 RBLWR NET174 SAEB SAEBRT SAOFF STCLK STCLKWR T1B WRREF
+Z0B me84a03_RIO_LOGIC1_LITE
XXIO00 BBL0 BBL1 BTL0 BTL1 CCRDL D0 DCLKBL LOG0 LOG1 LWEL LWEL
+PRCHRDBL2 PRCHRDBL3 Q0 SAEBL me84a03_IOCM2_LITE_LC
XXIO01 BBL2 BBL3 BTL2 BTL3 CCRDL D1 DCLKBL LOG0 LOG1 LWEL LWEL
+PRCHRDBL0 PRCHRDBL1 Q1 SAEBL me84a03_IOCM2_LITE_LC
XXIO03 BBR0 BBR1 BTR0 BTR1 CCRD D2 DCLKBR LOG0 LOG1 LWER LWER
+PRCHRDBR0 PRCHRDBR1 Q2 SAEB me84a03_IOCM2_LITE_LC
XXIO04 BBR2 BBR3 BTR2 BTR3 CCRD D3 DCLKBR LOG0 LOG1 LWER LWER
+PRCHRDBR2 PRCHRDBR3 Q3 SAEB me84a03_IOCM2_LITE_LC
XXCENTER ACUTRK CCOR CCRDL CCRD CCWR DCLKBL DCLKBR LWEL LWER MCLK NET95 NET210
+PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1 PARDB0
+PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9 PBRDB8
+PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1 PBRDB0
+PRCHRDBL3 PRCHRDBL2 PRCHRDBL1 PRCHRDBL0 PRCHRDBR3 PRCHRDBR2
+PRCHRDBR1 PRCHRDBR0 NET177 NET215 NET94 RMENB NET174 SAEBL SAOFF T1B
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 NET93 NET212 Z0B Z2 Z1 Z0 LOG0
+LOG1 RM0N RM0N VDD RM0N1 RM0N RM1N RM1P1 RM1N RM1N VSS SAEBRT CLK ME NET215
+RMDEF2 RMDEF1 RMDEF0 RMEN RMENB RMEN RM3 RM2 RM1 RM0 RMFAST2
+RMFAST1 RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 RST NET210 STCLK STCLKWR
+NET212 TEST1 WE XA6 XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0
+me84a03_CENTER_LITE_LC
XIX8DEC WLL7 WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 WLR7 WLR6
+WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 ACUTRK NET110 NET109 WRREF Z2 Z1
+Z0 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1 PARDB0
+PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9 PBRDB8
+PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1 PBRDB0 NET177
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 me84a03_X8DEC_LC
.ENDS me84a03_X1P11CM2_LITE_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_STRAP4_BOT                                                           *
* LAST TIME SAVED:  MAY 08 15:23:02 2014                                      *
*******************************************************************************
.SUBCKT me84a03_STRAP4_BOT SUP
*.PININFO SUP:B
XI3 SUP me84a03_STRAP_BOT
XI2 SUP me84a03_STRAP_BOT
XI5 SUP me84a03_STRAP_BOT
XI4 SUP me84a03_STRAP_BOT
.ENDS me84a03_STRAP4_BOT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_BWAR4_RET                                                            *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_BWAR4_RET BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 LOG0 LOG1 RWL
+RWLD
*.PININFO BB0:B BB1:B BB2:B BB3:B BT0:B BT1:B BT2:B BT3:B LOG0:B LOG1:B
*.PININFO RWL:I RWLD:I
XI3 LOG0 me84a03_STRAP4_BOT
XI437 BB3 BT3 NET0 NET22 NET19 NET23 VDD LOG0 RWL me84a03_RAM6X_SPLIT
XI605 BB3 BT3 NET1 NET22 NET20 NET24 VDD LOG0 RWLD me84a03_RAM6X_SPLIT
XI435 BB1 BT1 NET2 NET34 NET31 NET35 VDD RWL me84a03_RAM6X
XI607 BB1 BT1 NET3 NET34 NET32 NET36 VDD RWLD me84a03_RAM6X
XI452 BB2 BT2 NET4 NET28 NET25 NET29 VDD RWL me84a03_RAM6X
XI606 BB2 BT2 NET5 NET28 NET26 NET30 VDD RWLD me84a03_RAM6X
XI275 BB0 BT0 NET6 NET40 NET37 NET41 VDD RWL me84a03_RAM6X
XI619 BB0 BT0 NET7 NET40 NET38 NET42 VDD RWLD me84a03_RAM6X
.ENDS me84a03_BWAR4_RET

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_BWAR4                                                                *
* LAST TIME SAVED:  MAY 08 15:23:01 2014                                      *
*******************************************************************************
.SUBCKT me84a03_BWAR4 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 LOG0 LOG1 RWL RWLD
*.PININFO BB0:B BB1:B BB2:B BB3:B BT0:B BT1:B BT2:B BT3:B LOG0:I LOG1:I
*.PININFO RWL:I RWLD:I
XI435 BB1 BT1 NET0 NET37 NET34 NET39 VDD RWL me84a03_RAM6X
XI607 BB1 BT1 NET1 NET37 NET35 NET38 VDD RWLD me84a03_RAM6X
XI452 BB2 BT2 NET2 NET31 NET28 NET32 VDD RWL me84a03_RAM6X
XI606 BB2 BT2 NET3 NET31 NET29 NET33 VDD RWLD me84a03_RAM6X
XI437 BB3 BT3 NET4 NET24 NET21 NET26 VDD RWL me84a03_RAM6X
XI605 BB3 BT3 NET5 NET24 NET22 NET27 VDD RWLD me84a03_RAM6X
XI275 BB0 BT0 NET6 NET42 NET25 NET43 VDD RWL me84a03_RAM6X
XI619 BB0 BT0 NET7 NET42 NET40 NET44 VDD RWLD me84a03_RAM6X
XI27 LOG0 me84a03_STRAP4_BOT
.ENDS me84a03_BWAR4

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WAR4_RT                                                              *
* LAST TIME SAVED:  MAY 08 15:22:51 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WAR4_RT BB7 BB6 BB5 BB4 BB3 BB2 BB1 BB0 BT7 BT6
+BT5 BT4 BT3 BT2 BT1 BT0 LOG0 LOG1 RWL RWLD
*.PININFO BB7:B BB6:B BB5:B BB4:B BB3:B BB2:B BB1:B BB0:B BT7:B BT6:B
*.PININFO BT5:B BT4:B BT3:B BT2:B BT1:B BT0:B LOG0:B LOG1:B RWL:I RWLD:I
XI435 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 LOG0 LOG1 RWL RWLD
+me84a03_BWAR4_RET
XI2 LOG0 LOG0 me84a03_RAM_EDGE2
XI464 BB4 BB5 BB6 BB7 BT4 BT5 BT6 BT7 LOG0 LOG1 LOG0 LOG0 me84a03_BWAR4
.ENDS me84a03_WAR4_RT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_STRAP4                                                               *
* LAST TIME SAVED:  MAY 08 15:23:14 2014                                      *
*******************************************************************************
.SUBCKT me84a03_STRAP4 SUP
*.PININFO SUP:B
XI3 SUP me84a03_STRAP
XI2 SUP me84a03_STRAP
XI5 SUP me84a03_STRAP
XI4 SUP me84a03_STRAP
.ENDS me84a03_STRAP4

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_BAR4                                                                 *
* LAST TIME SAVED:  MAY 08 15:23:02 2014                                      *
*******************************************************************************
.SUBCKT me84a03_BAR4 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 WL0 WL1
*.PININFO BB0:B BB1:B BB2:B BB3:B BT0:B BT1:B BT2:B BT3:B WL0:I WL1:I
XI342 BB3 BT3 WL1 me84a03_RAM6T
XI345 BB3 BT3 WL0 me84a03_RAM6T
XI356 BB2 BT2 WL1 me84a03_RAM6T
XI359 BB2 BT2 WL0 me84a03_RAM6T
XI328 BB1 BT1 WL1 me84a03_RAM6T
XI331 BB1 BT1 WL0 me84a03_RAM6T
XI273 BB0 BT0 WL1 me84a03_RAM6T
XI275 BB0 BT0 WL0 me84a03_RAM6T
.ENDS me84a03_BAR4

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_AR4_RT                                                               *
* LAST TIME SAVED:  MAY 08 15:23:05 2014                                      *
*******************************************************************************
.SUBCKT me84a03_AR4_RT BB7 BB6 BB5 BB4 BB3 BB2 BB1 BB0 BT7 BT6 BT5
+ BT4 BT3 BT2 BT1 BT0 LOG0 WL7 WL6 WL5 WL4 WL3 WL2 WL1
+WL0
*.PININFO BB7:B BB6:B BB5:B BB4:B BB3:B BB2:B BB1:B BB0:B BT7:B BT6:B
*.PININFO BT5:B BT4:B BT3:B BT2:B BT1:B BT0:B LOG0:B WL7:I WL6:I WL5:I
*.PININFO WL4:I WL3:I WL2:I WL1:I WL0:I
XI20 LOG0 me84a03_STRAP4
XI58 LOG0 me84a03_STRAP4
XI57 LOG0 me84a03_STRAP4
XI19 LOG0 me84a03_STRAP4_BOT
XI18 LOG0 me84a03_STRAP4_BOT
XI21 LOG0 me84a03_STRAP2
XI55 WL4 WL5 me84a03_RAM_EDGE2
XI45 WL2 WL3 me84a03_RAM_EDGE2
XI56 WL6 WL7 me84a03_RAM_EDGE2
XI54 WL0 WL1 me84a03_RAM_EDGE2
XI435 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 WL0 WL1 me84a03_BAR4
XI525 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 WL2 WL3 me84a03_BAR4
XI52 BB4 BB5 BB6 BB7 BT4 BT5 BT6 BT7 WL4 WL5 me84a03_BAR4
XI53 BB4 BB5 BB6 BB7 BT4 BT5 BT6 BT7 WL6 WL7 me84a03_BAR4
XI51 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 WL4 WL5 me84a03_BAR4
XI6 BB4 BB5 BB6 BB7 BT4 BT5 BT6 BT7 WL0 WL1 me84a03_BAR4
XI9 BB4 BB5 BB6 BB7 BT4 BT5 BT6 BT7 WL2 WL3 me84a03_BAR4
XI50 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 WL6 WL7 me84a03_BAR4
.ENDS me84a03_AR4_RT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WAR4_LT                                                              *
* LAST TIME SAVED:  MAY 08 15:22:54 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WAR4_LT BB7 BB6 BB5 BB4 BB3 BB2 BB1 BB0 BT7 BT6
+BT5 BT4 BT3 BT2 BT1 BT0 LOG0 LOG1 RWL RWLD
*.PININFO BB7:B BB6:B BB5:B BB4:B BB3:B BB2:B BB1:B BB0:B BT7:B BT6:B
*.PININFO BT5:B BT4:B BT3:B BT2:B BT1:B BT0:B LOG0:B LOG1:B RWL:I RWLD:I
XI435 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 LOG0 LOG1 RWL RWLD
+me84a03_BWAR4_RET
XI11 RWLD RWL me84a03_RAM_EDGE2
XI2 LOG0 LOG0 me84a03_RAM_EDGE2
XI464 BB4 BB5 BB6 BB7 BT4 BT5 BT6 BT7 LOG0 LOG1 LOG0 LOG0 me84a03_BWAR4
.ENDS me84a03_WAR4_LT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_AR4_LT                                                               *
* LAST TIME SAVED:  MAY 08 15:23:03 2014                                      *
*******************************************************************************
.SUBCKT me84a03_AR4_LT BB7 BB6 BB5 BB4 BB3 BB2 BB1 BB0 BT7 BT6 BT5
+ BT4 BT3 BT2 BT1 BT0 LOG0 WL7 WL6 WL5 WL4 WL3 WL2 WL1
+WL0
*.PININFO BB7:B BB6:B BB5:B BB4:B BB3:B BB2:B BB1:B BB0:B BT7:B BT6:B
*.PININFO BT5:B BT4:B BT3:B BT2:B BT1:B BT0:B LOG0:B WL7:I WL6:I WL5:I
*.PININFO WL4:I WL3:I WL2:I WL1:I WL0:I
XI20 LOG0 me84a03_STRAP4
XI58 LOG0 me84a03_STRAP4
XI57 LOG0 me84a03_STRAP4
XI19 LOG0 me84a03_STRAP4_BOT
XI18 LOG0 me84a03_STRAP4_BOT
XI21 LOG0 me84a03_STRAP2
XI55 WL4 WL5 me84a03_RAM_EDGE2
XI45 WL2 WL3 me84a03_RAM_EDGE2
XI60 WL4 WL5 me84a03_RAM_EDGE2
XI59 WL6 WL7 me84a03_RAM_EDGE2
XI62 WL0 WL1 me84a03_RAM_EDGE2
XI56 WL6 WL7 me84a03_RAM_EDGE2
XI54 WL0 WL1 me84a03_RAM_EDGE2
XI61 WL2 WL3 me84a03_RAM_EDGE2
XI435 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 WL0 WL1 me84a03_BAR4
XI525 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 WL2 WL3 me84a03_BAR4
XI52 BB4 BB5 BB6 BB7 BT4 BT5 BT6 BT7 WL4 WL5 me84a03_BAR4
XI53 BB4 BB5 BB6 BB7 BT4 BT5 BT6 BT7 WL6 WL7 me84a03_BAR4
XI51 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 WL4 WL5 me84a03_BAR4
XI6 BB4 BB5 BB6 BB7 BT4 BT5 BT6 BT7 WL0 WL1 me84a03_BAR4
XI9 BB4 BB5 BB6 BB7 BT4 BT5 BT6 BT7 WL2 WL3 me84a03_BAR4
XI50 BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 WL6 WL7 me84a03_BAR4
.ENDS me84a03_AR4_LT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RXR1K4                                                               *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RXR1K4 BB BT RREF CC
*.PININFO BB:B BT:B RREF:B CC:I
XMI352 BB PRCHB RREF VSS N12_LP W=3.04U L=me84a03_LD M=1
XMI250 BT PRCHB VDD VDD P12_LP W=1.4U L=me84a03_LD M=1
XMI252 BB PRCHB VDD VDD P12_LP W=1.4U L=me84a03_LD M=1
XMI366 RREF PRCH BB VDD P12_LP W=1.4U L=me84a03_LD M=1
XI395 PRCHB PRCH me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.6U WP=1.2U
XI0 PRCH CC me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.5U WP=1.0U
.ENDS me84a03_RXR1K4

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_STGENRD                                                              *
* LAST TIME SAVED:  MAY 08 15:23:05 2014                                      *
*******************************************************************************
.SUBCKT me84a03_STGENRD STCLK STCLKTW CCLK CCORD RDT1B RREF LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO STCLK:O STCLKTW:O CCLK:I CCORD:I RDT1B:I RREF:I
XMI888 VDD CCLK RREF VDD P12_LP W=1.0U L=me84a03_LPD M=1
XMI889 VDD CCLK STCLK VDD P12_LP W=3.0U L=me84a03_LPD M=1
XMI841 STCLKB ICC VSS VSS N12_LP W=0.4U L=me84a03_LD M=1
XI825 ICC CCLK me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.15U
XI854 STCLKB RREF me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=2.4U
XI9 STCLKTW STCLKB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.15U
XI8 CCRD NET18 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.3U
XI7 NET18 RDT1B CCORD me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
XI20 STCLK CCRD STCLKB me84a03_ND2 WN1=4.2U WN2=4.2U WP1=0.3U WP2=0.3U
.ENDS me84a03_STGENRD

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RIOCC                                                                *
* LAST TIME SAVED:  MAY 08 15:23:04 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RIOCC CCORW CCWRT CCOR CCWR RW_RBL LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO CCORW:O CCWRT:O CCOR:I CCWR:I RW_RBL:I
XI54 NET026 RW_RBL me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI51 CCWRT NET065 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.25U WP=0.5U
XI48 NET0114 NET092 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.3U
XI46 CCORW NET0116 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI45 NET0116 NET0114 CCOR me84a03_NR2 WN1=0.3U WN2=0.3U WP1=0.6U WP2=0.6U
XI49 NET065 CCWR NET026 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
XI47 NET092 CCWR RW_RBL me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_RIOCC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RIO_BL_LITE                                                          *
* LAST TIME SAVED:  MAY 08 15:22:55 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RIO_BL_LITE CCOR CCRD CCWR DCLKB LOG0 LOG1 LWE MCLK PCB0 PCB1 PCB2
+ PCB3 RBLRD RBLWR RT1 RW_RBL SAEBR SAEBRT SAOFF STCLK STCLKWR T1B WRREF LN=me84a03_LND
+ LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO CCOR:I CCRD:B CCWR:I DCLKB:B LOG0:B LOG1:B LWE:B MCLK:I PCB0:B PCB1:B
*.PININFO PCB2:B PCB3:B RBLRD:B RBLWR:I RT1:B RW_RBL:I SAEBR:O SAEBRT:O SAOFF:I
*.PININFO STCLK:O STCLKWR:O T1B:I WRREF:I
XI520 RBLRD RT1 RREF CCORW me84a03_RXR1K4
XI0 SAEBRT SAOFF STCLKMUX me84a03_NR2 WN1=1.6U WN2=1.6U WP1=10U WP2=10U
XI28 STCLKMUX STCLK MCLK T1T me84a03_IMUX2ST
XI649 STCLK NET65 CCORW CCOR T1B RREF me84a03_STGENRD
XI42 STCLKWR RBLWR WRREF CCWR CCWRT LOG1 RW_RBL STCLKB me84a03_STGENWR
XI49 CCORW CCWRT CCOR CCWR RW_RBL me84a03_RIOCC
XI22 SAEBR SAEBRT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=8.8U WP=5.2U
XI50 STCLKB NET65 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.7U
XI56 T1T T1B me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.5U WP=1.0U
.ENDS me84a03_RIO_BL_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CMUX4                                                                *
* LAST TIME SAVED:  MAY 08 15:23:01 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CMUX4 BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 RDB RDT WRB WRT
+PCB3 PCB2 PCB1 PCB0
*.PININFO BB3:B BB2:B BB1:B BB0:B BT3:B BT2:B BT1:B BT0:B RDB:B RDT:B
*.PININFO WRB:B WRT:B PCB3:I PCB2:I PCB1:I PCB0:I
XX0 BB0 BT0 RDB RDT WRB WRT PCB0 me84a03_CMUX
XX1 BB1 BT1 RDB RDT WRB WRT PCB1 me84a03_CMUX
XX2 BB2 BT2 RDB RDT WRB WRT PCB2 me84a03_CMUX
XXM BB3 BT3 RDB RDT WRB WRT PCB3 me84a03_CMUX
.ENDS me84a03_CMUX4

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM4_LITE_LC                                                        *
* LAST TIME SAVED:  MAY 08 15:22:56 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM4_LITE_LC BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 CCRD DA
+DCLKB LOG0 LOG1 LWE PCB0 PCB1 PCB2 PCB3 Q SAEB WEMA WEMA_AH WEMA_AL
+WEMA_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BB2:B BB3:B BT0:B BT1:B BT2:B BT3:B CCRD:I DA:I
*.PININFO DCLKB:I LOG0:B LOG1:B LWE:I PCB0:B PCB1:B PCB2:B PCB3:B Q:O SAEB:I
*.PININFO WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET039 LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET040 CCRD me84a03_LSA1
XXDO NET27 Q WEMA_AH WEMA_AL DA LQT WEMA me84a03_DO_LITE_LC
XXMX BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 RDB RDT WRB WRT PCB3
+PCB2 PCB1 PCB0 me84a03_CMUX4
DI30 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
DI29 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
XXDI WRB WRT DCLKB NET27 LWE WEMA_IN me84a03_WRDRV_LITE_LC
XI36 NET040 SAEB NET039 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM4_LITE_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X1P11CM4_LITE_LC                                                     *
* LAST TIME SAVED:  MAY 08 15:23:13 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X1P11CM4_LITE_LC Q3 Q2 Q1 Q0 CLK D3 D2 D1 D0 ME RM3
+RM2 RM1 RM0 RMDEF2 RMDEF1 RMDEF0 RMEN RMFAST2 RMFAST1 RMFAST0
+ RMSLOW2 RMSLOW1 RMSLOW0 RST TEST1 WE WEM3 WEM2 WEM1 WEM0 XA6
+XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LN3=me84a03_LND
+LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD LP3=me84a03_LPD
*.PININFO Q3:O Q2:O Q1:O Q0:O CLK:I D3:I D2:I D1:I D0:I ME:I RM3:I
*.PININFO RM2:I RM1:I RM0:I RMDEF2:I RMDEF1:I RMDEF0:I RMEN:I RMFAST2:I
*.PININFO RMFAST1:I RMFAST0:I RMSLOW2:I RMSLOW1:I RMSLOW0:I RST:I TEST1:I WE:I
*.PININFO WEM3:I WEM2:I WEM1:I WEM0:I XA6:I XA5:I XA4:I XA3:I XA2:I
*.PININFO XA1:I XA0:I YA1:I YA0:I
XXWARREF LOG0 LOG1 RBLRD RBLWR RWLR RWLR me84a03_WARREF
XXWAR4R BBR7 BBR6 BBR5 BBR4 BBR3 BBR2 BBR1 BBR0 BTR7 BTR6
+BTR5 BTR4 BTR3 BTR2 BTR1 BTR0 LOG0 LOG1 RWLR RWLR me84a03_WAR4_RT
XXARRR BBR7 BBR6 BBR5 BBR4 BBR3 BBR2 BBR1 BBR0 BTR7 BTR6
+BTR5 BTR4 BTR3 BTR2 BTR1 BTR0 LOG0 WLR7 WLR6 WLR5 WLR4
+WLR3 WLR2 WLR1 WLR0 me84a03_AR4_RT
XI19 LOG0 LOG1 me84a03_CAP_RT
XXHSLREF LOG0 RBLRD RBLWR WLR7 WLR6 WLR5 WLR4 WLR3 WLR2 WLR1
+WLR0 me84a03_HSLREF
XXWAR4L BBL7 BBL6 BBL5 BBL4 BBL3 BBL2 BBL1 BBL0 BTL7 BTL6
+BTL5 BTL4 BTL3 BTL2 BTL1 BTL0 LOG0 LOG1 RWLL RWLL me84a03_WAR4_LT
XXARRL BBL7 BBL6 BBL5 BBL4 BBL3 BBL2 BBL1 BBL0 BTL7 BTL6
+BTL5 BTL4 BTL3 BTL2 BTL1 BTL0 LOG0 WLL7 WLL6 WLL5 WLL4
+WLL3 WLL2 WLL1 WLL0 me84a03_AR4_LT
XI20 LOG0 LOG1 me84a03_CAP_LT
XXRW RWLL RWLR WRREF LOG0 LOG1 RBLRD RBLWR NET127 NET126 WCLKRD0 WCLKRDB0
+ACUTRK RWLR Z2 Z1 Z0 me84a03_RW_LC
XXRIO CCOR CCRD CCWR DCLKBR LOG0 LOG1 LWER MCLK PRCHRDBR0 PRCHRDBR1
+PRCHRDBR2 PRCHRDBR3 RBLRD RBLWR NET97 NET195 SAEB SAEBRT SAOFF STCLK
+STCLKWR T1B WRREF me84a03_RIO_BL_LITE
XXIO00 BBL0 BBL1 BBL2 BBL3 BTL0 BTL1 BTL2 BTL3 CCRDL D0 DCLKBL
+LOG0 LOG1 LWEL PRCHRDBL0 PRCHRDBL1 PRCHRDBL2 PRCHRDBL3 Q0 SAEBRL
+WEM0 NET306 NET102 NET306 me84a03_IOCM4_LITE_LC
XXIO01 BBL4 BBL5 BBL6 BBL7 BTL4 BTL5 BTL6 BTL7 CCRDL D1 DCLKBL
+LOG0 LOG1 LWEL PRCHRDBL0 PRCHRDBL1 PRCHRDBL2 PRCHRDBL3 Q1 SAEBRL
+WEM1 NET303 NET101 NET303 me84a03_IOCM4_LITE_LC
XXIO04 BBR4 BBR5 BBR6 BBR7 BTR4 BTR5 BTR6 BTR7 CCRD D3 DCLKBR
+LOG0 LOG1 LWER PRCHRDBR0 PRCHRDBR1 PRCHRDBR2 PRCHRDBR3 Q3 SAEB WEM3
+NET298 NET95 NET298 me84a03_IOCM4_LITE_LC
XXIO03 BBR0 BBR1 BBR2 BBR3 BTR0 BTR1 BTR2 BTR3 CCRD D2 DCLKBR
+LOG0 LOG1 LWER PRCHRDBR0 PRCHRDBR1 PRCHRDBR2 PRCHRDBR3 Q2 SAEB WEM2
+NET309 NET96 NET309 me84a03_IOCM4_LITE_LC
XXCENTER ACUTRK CCOR CCRDL CCRD CCWR DCLKBL DCLKBR LWEL LWER MCLK NET221 NET222
+PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1 PARDB0
+PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9 PBRDB8
+PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1 PBRDB0
+PRCHRDBL3 PRCHRDBL2 PRCHRDBL1 PRCHRDBL0 PRCHRDBR3 PRCHRDBR2
+PRCHRDBR1 PRCHRDBR0 NET201 NET218 NET216 RMENB NET195 SAEBRL SAOFF T1B
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 NET100 NET219 Z0B Z2 Z1 Z0 LOG0
+ LOG1 RM0N RM0N VDD RM0N1 RM0N RM1N RM1P1 RM1N RM1N VSS SAEBRT CLK ME NET216
+RMDEF2 RMDEF1 RMDEF0 RMEN RMENB RMEN RM3 RM2 RM1 RM0 RMFAST2
+RMFAST1 RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 RST NET222 STCLK STCLKWR
+NET219 TEST1 WE XA6 XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0
+me84a03_CENTER_LITE_LC
XIX8DEC WLL7 WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 WLR7 WLR6
+WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 ACUTRK NET127 NET126 WRREF Z2 Z1
+Z0 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1 PARDB0
+PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9 PBRDB8
+PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1 PBRDB0 NET201
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 me84a03_X8DEC_LC
.ENDS me84a03_X1P11CM4_LITE_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CBUF_LC                                                              *
* LAST TIME SAVED:  MAY 08 15:23:09 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CBUF_LC AWT BCBL BCTL BISTE CCRDL CSHARE DCLKBL FLOATI LA0QB LA0QT LA1QB
+ LWEI LWEL PRCHBL0 PRCHBL1 PRCHBL2 PRCHBL3 PRCLK SAEBL SAEBRT SAOFF
+SWBAWTBL SWBAWTL
*.PININFO AWT:I BCBL:O BCTL:O BISTE:I CCRDL:O CSHARE:I DCLKBL:O FLOATI:I LA0QB:I LA0QT:I
*.PININFO LA1QB:I LWEI:I LWEL:O PRCHBL0:O PRCHBL1:O PRCHBL2:O PRCHBL3:O PRCLK:I
*.PININFO SAEBL:O SAEBRT:I SAOFF:I SWBAWTBL:O SWBAWTL:O
XI131 PRCHBL3 LA0QT CSHARE PRCLK me84a03_DEC2TO1_LC
XI130 PRCHBL2 LA0QB CSHARE PRCLK me84a03_DEC2TO1_LC
XI129 PRCHBL1 LA0QT LA1QB PRCLK me84a03_DEC2TO1_LC
XI128 PRCHBL0 LA0QB LA1QB PRCLK me84a03_DEC2TO1_LC
XI54 LWEL LWEI me84a03_INV LN=me84a03_LD LP=0.07U WN=3U WP=6.96U
XI0 CCRDL SAOFF me84a03_INV LN=me84a03_LD LP=0.07U WN=3U WP=6.96U
XI55 DCLKBL FLOATI me84a03_INV LN=0.07U LP=me84a03_LD WN=3.48U WP=6U
XI23 SAEBL SAEBRT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=8.8U WP=5.2U
XI48 SWBAWTL SWBAWTBL me84a03_INVH LN=0.07U LP=0.07U WN=1.5U WP=3.0U
XI47 SWBAWTBL AWT me84a03_INVH LN=0.07U LP=0.07U WN=1.5U WP=3.0U
XI20 BCBL BISTE me84a03_INVH LN=0.07U LP=0.07U WN=1.5U WP=3.0U
XI21 BCTL BCBL me84a03_INVH LN=0.07U LP=0.07U WN=1.5U WP=3.0U
.ENDS me84a03_CBUF_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CENTER_SD_LC                                                         *
* LAST TIME SAVED:  MAY 08 15:23:11 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CENTER_SD_LC ACUTRK AWT BCBR BCTR BISTE CCOR CCRDR CCWR CLK DCLKBR
+FLOATI LOG0 LOG1 LWEI LWER MCLK ME MERDA0 MERDA1 PARDB0 PARDB1 PARDB2
+PARDB3 PARDB4 PARDB5 PARDB6 PARDB7 PBRDB0 PBRDB1 PBRDB10
+PBRDB11 PBRDB12 PBRDB13 PBRDB14 PBRDB15 PBRDB2 PBRDB3 PBRDB4
+PBRDB5 PBRDB6 PBRDB7 PBRDB8 PBRDB9 PCBR0 PCBR1 PCBR2 PCBR3
+PRCLKRD PRM00 PRM01 PRM02 PRM03 PRM04 PRM10 PRM11 PRM12 PRM13
+ PRM14 QM RCSHARE RDOFF RLYA0QB RLYA0QT RLYA1QB RLYA1QT RMDEF0 RMDEF1
+RMDEF2 RMEN RMENB RMENI0 RMENI1 RMEXT0 RMEXT1 RMEXT2 RMEXT3
+RMFAST0 RMFAST1 RMFAST2 RMSLOW0 RMSLOW1 RMSLOW2 RST RW_RBL SAEBRT
+SAOFF SMERD STCLK STCLKWR SWBAWTBR SWBAWTR SWE T1B TCLK TEST1 TME TWE TXARD0
+TXARD1 TXARD2 TXARD3 TXARD4 TXARD5 TXARD6 TYARD0 TYARD1
+WCLKRD0 WCLKRD1 WCLKRDB0 WCLKRDB1 WE WEA0 WEA1 XARD0 XARD1 XARD2
+XARD3 XARD4 XARD5 XARD6 YARD0 YARD1 Z0 Z0B Z1 Z2 LN=me84a03_LND LN1=me84a03_LND
+ LN2=me84a03_LND LN3=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD LP3=me84a03_LPD
*.PININFO ACUTRK:O AWT:I BCBR:O BCTR:O BISTE:I CCOR:O CCRDR:O CCWR:O CLK:I DCLKBR:O
*.PININFO FLOATI:O LOG0:B LOG1:B LWEI:O LWER:O MCLK:O ME:I MERDA0:O MERDA1:O PARDB0:O
*.PININFO PARDB1:O PARDB2:O PARDB3:O PARDB4:O PARDB5:O PARDB6:O PARDB7:O
*.PININFO PBRDB0:O PBRDB1:O PBRDB10:O PBRDB11:O PBRDB12:O PBRDB13:O
*.PININFO PBRDB14:O PBRDB15:O PBRDB2:O PBRDB3:O PBRDB4:O PBRDB5:O PBRDB6:O
*.PININFO PBRDB7:O PBRDB8:O PBRDB9:O PCBR0:O PCBR1:O PCBR2:O PCBR3:O
*.PININFO PRCLKRD:O PRM00:B PRM01:B PRM02:B PRM03:B PRM04:B PRM10:B PRM11:B
*.PININFO PRM12:B PRM13:B PRM14:B QM:O RCSHARE:I RDOFF:O RLYA0QB:O RLYA0QT:O
*.PININFO RLYA1QB:O RLYA1QT:O RMDEF0:I RMDEF1:I RMDEF2:I RMEN:I RMENB:O RMENI0:I
*.PININFO RMENI1:I RMEXT0:I RMEXT1:I RMEXT2:I RMEXT3:I RMFAST0:I RMFAST1:I
*.PININFO RMFAST2:I RMSLOW0:I RMSLOW1:I RMSLOW2:I RST:I RW_RBL:O SAEBRT:B SAOFF:O
*.PININFO SMERD:I STCLK:I STCLKWR:I SWBAWTBR:O SWBAWTR:O SWE:I T1B:O TCLK:I TEST1:I TME:I
*.PININFO TWE:I TXARD0:I TXARD1:I TXARD2:I TXARD3:I TXARD4:I TXARD5:I
*.PININFO TXARD6:I TYARD0:I TYARD1:I WCLKRD0:O WCLKRD1:O WCLKRDB0:O
*.PININFO WCLKRDB1:O WE:I WEA0:O WEA1:O XARD0:I XARD1:I XARD2:I XARD3:I
*.PININFO XARD4:I XARD5:I XARD6:I YARD0:I YARD1:I Z0:O Z0B:O Z1:O Z2:O
XI37 LOG0 me84a03_LOG
XI56 ACUTRK RMENB RW_RBL Z0B Z2 Z1 Z0 PRM04 PRM03 PRM02 PRM01
+PRM00 PRM14 PRM13 PRM12 PRM11 PRM10 RMDEF2 RMDEF1 RMDEF0 RMEN
+RMENI1 RMENI0 RMEXT3 RMEXT2 RMEXT1 RMEXT0 RMFAST2 RMFAST1
+RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 me84a03_RMMX_LC
XXADRD RLYA0QB RLYA0QT RLYA1QB RLYA1QT PARDB7 PARDB6 PARDB5 PARDB4
+PARDB3 PARDB2 PARDB1 PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12
+PBRDB11 PBRDB10 PBRDB9 PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4
+PBRDB3 PBRDB2 PBRDB1 PBRDB0 PCBR3 PCBR2 PCBR1 PCBR0 RCSHARE
+LCLKBRD LCLKTRD PRCLKRD QXARD6 QXARD5 QXARD4 QXARD3 QXARD2 QXARD1
+QXARD0 QYARD1 QYARD0 me84a03_ADRGEN_LC
XMI46 VDD LOG0 LOG1 VDD P12_LP W=6.0U L=me84a03_LD M=1
XXCENRD CCOR CCRDR CCWR DCLKBR FLOATI LCLKBRD LCLKTRD PRCLKRD RDOFF SAOFF
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 RFLOAT BCBR BCTR CLK LME LWE MCLK
+METRD RST STCLK STCLKWR T1B TCLK me84a03_CENRD_LC
XXADRRDMUX ADXOR QXARD6 QXARD5 QXARD4 QXARD3 QXARD2 QXARD1 QXARD0
+QYARD1 QYARD0 BCBR BCTR TXARD6 TXARD5 TXARD4 TXARD3 TXARD2
+TXARD1 TXARD0 TYARD1 TYARD0 XARD6 XARD5 XARD4 XARD3 XARD2
+XARD1 XARD0 YARD1 YARD0 me84a03_ADRMUX
XXR BCBR BCTR LME LWE LWEI LWER MCLK MERDA0 MERDA1 METRD QM SWBAWTBR SWBAWTR T1B
+ WEA0 WEA1 ADXOR AWT BISTE LCLKBRD CLK LCLKTRD ME SMERD SWE TCLK TEST1 TME TWE
+WE me84a03_CTRL_LC
XMI45 VSS LOG1 LOG0 VSS N12_LP W=6.0U L=me84a03_LD M=1
.ENDS me84a03_CENTER_SD_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CENTER_LC                                                            *
* LAST TIME SAVED:  MAY 08 15:22:50 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CENTER_LC ACUTRK BCBL BCBR BCTL BCTR CCOR CCRDL CCRDR CCWR DCLKBL DCLKBR
+ LWEL LWER MCLK MERDA0 MERDA1 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3
+PARDB2 PARDB1 PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11
+PBRDB10 PBRDB9 PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3
+PBRDB2 PBRDB1 PBRDB0 PCBL3 PCBL2 PCBL1 PCBL0 PCBR3 PCBR2
+PCBR1 PCBR0 QM RDOFF RLYA1QB RLYA1QT RMENB RW_RBL SAEBL SAOFF SWBAWTBL
+SWBAWTBR SWBAWTL SWBAWTR T1B WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 WEA0
+WEA1 Z0B Z2 Z1 Z0 LOG0 LOG1 PRM04 PRM03 PRM02 PRM01 PRM00
+PRM14 PRM13 PRM12 PRM11 PRM10 SAEBRT AWT BISTE CLK ME RCSHARE
+RMDEF2 RMDEF1 RMDEF0 RMEN RMENI1 RMENI0 RMEXT3 RMEXT2 RMEXT1
+RMEXT0 RMFAST2 RMFAST1 RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 RST SMERD
+STCLK STCLKWR SWE TCLK TEST1 TME TWE TXARD6 TXARD5 TXARD4 TXARD3
+TXARD2 TXARD1 TXARD0 TYARD1 TYARD0 WE XARD6 XARD5 XARD4 XARD3
+ XARD2 XARD1 XARD0 YARD1 YARD0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LN3=me84a03_LND LP=me84a03_LPD
+LP1=me84a03_LPD LP2=me84a03_LPD LP3=me84a03_LPD
*.PININFO ACUTRK:O BCBL:O BCBR:O BCTL:O BCTR:O CCOR:O CCRDL:O CCRDR:O CCWR:O DCLKBL:O
*.PININFO DCLKBR:O LWEL:O LWER:O MCLK:O MERDA0:O MERDA1:O PARDB7:O PARDB6:O PARDB5:O
*.PININFO PARDB4:O PARDB3:O PARDB2:O PARDB1:O PARDB0:O PBRDB15:O PBRDB14:O
*.PININFO PBRDB13:O PBRDB12:O PBRDB11:O PBRDB10:O PBRDB9:O PBRDB8:O PBRDB7:O
*.PININFO PBRDB6:O PBRDB5:O PBRDB4:O PBRDB3:O PBRDB2:O PBRDB1:O PBRDB0:O
*.PININFO PCBL3:O PCBL2:O PCBL1:O PCBL0:O PCBR3:O PCBR2:O PCBR1:O PCBR0:O
*.PININFO QM:O RDOFF:O RLYA1QB:O RLYA1QT:O RMENB:O RW_RBL:O SAEBL:O SAOFF:O SWBAWTBL:O
*.PININFO SWBAWTBR:O SWBAWTL:O SWBAWTR:O T1B:O WCLKRD1:O WCLKRD0:O WCLKRDB1:O
*.PININFO WCLKRDB0:O WEA0:O WEA1:O Z0B:O Z2:O Z1:O Z0:O LOG0:B LOG1:B PRM04:B
*.PININFO PRM03:B PRM02:B PRM01:B PRM00:B PRM14:B PRM13:B PRM12:B PRM11:B
*.PININFO PRM10:B SAEBRT:B AWT:I BISTE:I CLK:I ME:I RCSHARE:I RMDEF2:I RMDEF1:I
*.PININFO RMDEF0:I RMEN:I RMENI1:I RMENI0:I RMEXT3:I RMEXT2:I RMEXT1:I
*.PININFO RMEXT0:I RMFAST2:I RMFAST1:I RMFAST0:I RMSLOW2:I RMSLOW1:I
*.PININFO RMSLOW0:I RST:I SMERD:I STCLK:I STCLKWR:I SWE:I TCLK:I TEST1:I TME:I TWE:I
*.PININFO TXARD6:I TXARD5:I TXARD4:I TXARD3:I TXARD2:I TXARD1:I TXARD0:I
*.PININFO TYARD1:I TYARD0:I WE:I XARD6:I XARD5:I XARD4:I XARD3:I XARD2:I
*.PININFO XARD1:I XARD0:I YARD1:I YARD0:I
XXCBUF AWT BCBL BCTL BISTE CCRDL RCSHARE DCLKBL FLOATI YA0QB YA0QT RLYA1QB LWEI
+LWEL PCBL0 PCBL1 PCBL2 PCBL3 PRCLK SAEBL SAEBRT SAOFF SWBAWTBL SWBAWTL
+me84a03_CBUF_LC
XXC ACUTRK AWT BCBR BCTR BISTE CCOR CCRDR CCWR CLK DCLKBR FLOATI LOG0 LOG1 LWEI
+LWER MCLK ME MERDA0 MERDA1 PARDB0 PARDB1 PARDB2 PARDB3 PARDB4
+PARDB5 PARDB6 PARDB7 PBRDB0 PBRDB1 PBRDB10 PBRDB11 PBRDB12
+PBRDB13 PBRDB14 PBRDB15 PBRDB2 PBRDB3 PBRDB4 PBRDB5 PBRDB6
+PBRDB7 PBRDB8 PBRDB9 PCBR0 PCBR1 PCBR2 PCBR3 PRCLK PRM00
+PRM01 PRM02 PRM03 PRM04 PRM10 PRM11 PRM12 PRM13 PRM14 QM
+RCSHARE RDOFF YA0QB YA0QT RLYA1QB RLYA1QT RMDEF0 RMDEF1 RMDEF2 RMEN RMENB
+RMENI0 RMENI1 RMEXT0 RMEXT1 RMEXT2 RMEXT3 RMFAST0 RMFAST1
+RMFAST2 RMSLOW0 RMSLOW1 RMSLOW2 RST RW_RBL SAEBRT SAOFF SMERD STCLK
+STCLKWR SWBAWTBR SWBAWTR SWE T1B TCLK TEST1 TME TWE TXARD0 TXARD1 TXARD2
+TXARD3 TXARD4 TXARD5 TXARD6 TYARD0 TYARD1 WCLKRD0 WCLKRD1
+WCLKRDB0 WCLKRDB1 WE WEA0 WEA1 XARD0 XARD1 XARD2 XARD3 XARD4
+XARD5 XARD6 YARD0 YARD1 Z0 Z0B Z1 Z2 me84a03_CENTER_SD_LC
.ENDS me84a03_CENTER_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X1P11CM2_LC                                                          *
* LAST TIME SAVED:  MAY 08 15:22:54 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X1P11CM2_LC Q3 Q2 Q1 Q0 QM AWT BISTE CLK D3 D2 D1 D0 ME
+RM3 RM2 RM1 RM0 RMDEF2 RMDEF1 RMDEF0 RMEN RMFAST2 RMFAST1
+RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 RST TCLK TD3 TD2 TD1 TD0 TEST1
+TME TWE TXA6 TXA5 TXA4 TXA3 TXA2 TXA1 TXA0 TYA1 TYA0 WE XA6
+ XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LN3=me84a03_LND
+ LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD LP3=me84a03_LPD
*.PININFO Q3:O Q2:O Q1:O Q0:O QM:O AWT:I BISTE:I CLK:I D3:I D2:I D1:I D0:I
*.PININFO ME:I RM3:I RM2:I RM1:I RM0:I RMDEF2:I RMDEF1:I RMDEF0:I RMEN:I
*.PININFO RMFAST2:I RMFAST1:I RMFAST0:I RMSLOW2:I RMSLOW1:I RMSLOW0:I RST:I
*.PININFO TCLK:I TD3:I TD2:I TD1:I TD0:I TEST1:I TME:I TWE:I TXA6:I TXA5:I
*.PININFO TXA4:I TXA3:I TXA2:I TXA1:I TXA0:I TYA1:I TYA0:I WE:I XA6:I
*.PININFO XA5:I XA4:I XA3:I XA2:I XA1:I XA0:I YA1:I YA0:I
XXWAR4R BBR3 BBR2 BBR1 BBR0 BTR3 BTR2 BTR1 BTR0 LOG0 LOG1 RWLR
+RWLR me84a03_WAR2_RT
XIX8DEC WLL7 WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 WLR7 WLR6
+WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 ACUTRK NET140 NET139 NET178 Z2 Z1
+ Z0 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1 PARDB0
+PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9 PBRDB8
+PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1 PBRDB0 NET289
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 me84a03_X8DEC_LC
XXIO00 BBL0 BBL1 BCBL BCTL BTL0 BTL1 CCRDL D0 DCLKBL LOG0 LOG1 LWEL
+LWEL PRCHRDBL2 PRCHRDBL3 Q0 SAEBL SWBAWTL SWBAWTBL TD0 me84a03_IOCM2_LC
XXIO01 BBL2 BBL3 BCBL BCTL BTL2 BTL3 CCRDL D1 DCLKBL LOG0 LOG1 LWEL
+LWEL PRCHRDBL0 PRCHRDBL1 Q1 SAEBL SWBAWTL SWBAWTBL TD1 me84a03_IOCM2_LC
XXIO03 BBR0 BBR1 BCBR BCTR BTR0 BTR1 CCRD D2 DCLKBR LOG0 LOG1 LWER
+LWER PRCHRDBR0 PRCHRDBR1 Q2 SAEB SWBAWTR SWBAWTBR TD2 me84a03_IOCM2_LC
XXIO04 BBR2 BBR3 BCBR BCTR BTR2 BTR3 CCRD D3 DCLKBR LOG0 LOG1 LWER
+LWER PRCHRDBR2 PRCHRDBR3 Q3 SAEB SWBAWTR SWBAWTBR TD3 me84a03_IOCM2_LC
XXCENTER ACUTRK BCBL BCBR BCTL BCTR CCOR CCRDL CCRD CCWR DCLKBL DCLKBR LWEL LWER
+ MCLK NET123 NET338 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2
+PARDB1 PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10
+PBRDB9 PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2
+PBRDB1 PBRDB0 PRCHRDBL3 PRCHRDBL2 PRCHRDBL1 PRCHRDBL0 PRCHRDBR3
+PRCHRDBR2 PRCHRDBR1 PRCHRDBR0 QM NET289 NET343 NET122 RMENB RW_RBL SAEBL
+SAOFF SWBAWTBL SWBAWTBR SWBAWTL SWBAWTR T1B WCLKRD1 WCLKRD0 WCLKRDB1
+WCLKRDB0 NET121 NET340 Z0B Z2 Z1 Z0 LOG0 LOG1 RM0N RM0N VDD RM0N1 RM0N
+RM1N RM1P1 RM1N RM1N VSS SAEBRT AWT BISTE CLK ME NET343 RMDEF2 RMDEF1
+RMDEF0 RMEN RMENB RMEN RM3 RM2 RM1 RM0 RMFAST2 RMFAST1 RMFAST0
+RMSLOW2 RMSLOW1 RMSLOW0 RST NET338 STCLK STCLKWR NET340 TCLK TEST1 TME
+TWE TXA6 TXA5 TXA4 TXA3 TXA2 TXA1 TXA0 TYA1 TYA0 WE XA6
+XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0 me84a03_CENTER_LC
XI19 LOG0 LOG1 me84a03_CAP_RT
XI20 LOG0 LOG1 me84a03_CAP_LT
XXHSLREF LOG0 RBLRD VSS WLR7 WLR6 WLR5 WLR4 WLR3 WLR2 WLR1 WLR0
+me84a03_HSLREF
XXARRR BBR3 BBR2 BBR1 BBR0 BTR3 BTR2 BTR1 BTR0 LOG0 WLR7
+WLR6 WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 me84a03_AR2_RT
XXARRL BBL3 BBL2 BBL1 BBL0 BTL3 BTL2 BTL1 BTL0 LOG0 WLL7
+WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 me84a03_AR2_LT
XXRIO BCBR BCTR CCOR CCRD CCWR DCLKBR LOG0 LOG1 LWER MCLK PRCHRDBR0
+PRCHRDBR1 PRCHRDBR2 PRCHRDBR3 VSS RW_RBL SAEB SAEBRT SAOFF STCLK STCLKWR
+SWBAWTR SWBAWTBR T1B NET178 Z0B me84a03_RIO_LOGIC1
XXWAR4L BBL3 BBL2 BBL1 BBL0 BTL3 BTL2 BTL1 BTL0 LOG0 LOG1 RWLL
+RWLL me84a03_WAR2_LT
XXWARREF LOG0 LOG1 RBLRD VSS RWLR RWLR me84a03_WARREF
XXRW RWLL RWLR NET178 LOG0 LOG1 RBLRD VSS NET140 NET139 WCLKRD0 WCLKRDB0
+ACUTRK RWLR Z2 Z1 Z0 me84a03_RW_LC
.ENDS me84a03_X1P11CM2_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RIO_BL                                                               *
* LAST TIME SAVED:  MAY 08 15:23:10 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RIO_BL BCB BCT CCOR CCRD CCWR DCLKB LOG0 LOG1 LWE MCLK PCB0 PCB1
+PCB2 PCB3 RBLRD RBLWR RT1 RW_RBL SAEBR SAEBRT SAOFF STCLK STCLKWR SWBAWT
+SWBAWTB T1B WRREF LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BCB:B BCT:B CCOR:I CCRD:B CCWR:I DCLKB:B LOG0:B LOG1:B LWE:B MCLK:I PCB0:B
*.PININFO PCB1:B PCB2:B PCB3:B RBLRD:B RBLWR:I RT1:B RW_RBL:I SAEBR:O SAEBRT:O
*.PININFO SAOFF:I STCLK:O STCLKWR:O SWBAWT:B SWBAWTB:B T1B:I WRREF:I
XI520 RBLRD RT1 RREF CCORW me84a03_RXR1K4
XI0 SAEBRT SAOFF STCLKMUX me84a03_NR2 WN1=1.6U WN2=1.6U WP1=10U WP2=10U
XI28 STCLKMUX STCLK MCLK T1T me84a03_IMUX2ST
XI649 STCLK NET65 CCORW CCOR T1B RREF me84a03_STGENRD
XI42 STCLKWR RBLWR WRREF CCWR CCWRT LOG1 RW_RBL STCLKB me84a03_STGENWR
XI49 CCORW CCWRT CCOR CCWR RW_RBL me84a03_RIOCC
XI22 SAEBR SAEBRT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=8.8U WP=5.2U
XI50 STCLKB NET65 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.7U
XI56 T1T T1B me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.5U WP=1.0U
.ENDS me84a03_RIO_BL

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM4_LC                                                             *
* LAST TIME SAVED:  MAY 08 15:23:05 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM4_LC BB0 BB1 BB2 BB3 BCB BCT BT0 BT1 BT2 BT3 CCRD DA
+ DCLKB LOG0 LOG1 LWE PCB0 PCB1 PCB2 PCB3 Q SAEB SWBAWT SWBAWTB TDA
+TWEMA WEMA WEMA_AH WEMA_AL WEMA_IN LN=me84a03_LND LN1=me84a03_LND
+LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BB2:B BB3:B BCB:I BCT:I BT0:B BT1:B BT2:B BT3:B
*.PININFO CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE:I PCB0:B PCB1:B PCB2:B PCB3:B Q:O
*.PININFO SAEB:I SWBAWT:I SWBAWTB:I TDA:I TWEMA:I WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET057 LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXMX BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 RDB RDT WRB WRT PCB3
+PCB2 PCB1 PCB0 me84a03_CMUX4
DI30 VSS DA HVTNDIO12_LP AREA=ARD PJ=PRD
DI34 VSS TDA HVTNDIO12_LP AREA=ARD PJ=PRD
DI35 VSS TWEMA HVTNDIO12_LP AREA=ARD PJ=PRD
DI29 VSS WEMA HVTNDIO12_LP AREA=ARD PJ=PRD
XXLSA SQB SQT RDT RDB SAE NET060 CCRD me84a03_LSA1
XXDI WRB WRT DCLKB NET43 LWE WEMA_IN me84a03_WRDRV_LITE_LC
XXDO NET43 Q WEMA_AH WEMA_AL BCB BCT DA LQT SWBAWT SWBAWTB TDA TWEMA WEMA me84a03_DO_LC
XI27 NET060 SAEB NET057 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM4_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X1P11CM4_LC                                                          *
* LAST TIME SAVED:  MAY 08 15:23:10 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X1P11CM4_LC Q3 Q2 Q1 Q0 QM AWT BISTE CLK D3 D2 D1 D0 ME
+RM3 RM2 RM1 RM0 RMDEF2 RMDEF1 RMDEF0 RMEN RMFAST2 RMFAST1
+RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 RST TCLK TD3 TD2 TD1 TD0 TEST1
+TME TWE TWEM3 TWEM2 TWEM1 TWEM0 TXA6 TXA5 TXA4 TXA3 TXA2
+TXA1 TXA0 TYA1 TYA0 WE WEM3 WEM2 WEM1 WEM0 XA6 XA5 XA4
+XA3 XA2 XA1 XA0 YA1 YA0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LN3=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD
+ LP2=me84a03_LPD LP3=me84a03_LPD
*.PININFO Q3:O Q2:O Q1:O Q0:O QM:O AWT:I BISTE:I CLK:I D3:I D2:I D1:I D0:I
*.PININFO ME:I RM3:I RM2:I RM1:I RM0:I RMDEF2:I RMDEF1:I RMDEF0:I RMEN:I
*.PININFO RMFAST2:I RMFAST1:I RMFAST0:I RMSLOW2:I RMSLOW1:I RMSLOW0:I RST:I
*.PININFO TCLK:I TD3:I TD2:I TD1:I TD0:I TEST1:I TME:I TWE:I TWEM3:I TWEM2:I
*.PININFO TWEM1:I TWEM0:I TXA6:I TXA5:I TXA4:I TXA3:I TXA2:I TXA1:I
*.PININFO TXA0:I TYA1:I TYA0:I WE:I WEM3:I WEM2:I WEM1:I WEM0:I XA6:I
*.PININFO XA5:I XA4:I XA3:I XA2:I XA1:I XA0:I YA1:I YA0:I
XXWARREF LOG0 LOG1 RBLRD RBLWR RWLR RWLR me84a03_WARREF
XXWAR4R BBR7 BBR6 BBR5 BBR4 BBR3 BBR2 BBR1 BBR0 BTR7 BTR6
+BTR5 BTR4 BTR3 BTR2 BTR1 BTR0 LOG0 LOG1 RWLR RWLR me84a03_WAR4_RT
XXARRR BBR7 BBR6 BBR5 BBR4 BBR3 BBR2 BBR1 BBR0 BTR7 BTR6
+BTR5 BTR4 BTR3 BTR2 BTR1 BTR0 LOG0 WLR7 WLR6 WLR5 WLR4
+WLR3 WLR2 WLR1 WLR0 me84a03_AR4_RT
XI19 LOG0 LOG1 me84a03_CAP_RT
XXHSLREF LOG0 RBLRD RBLWR WLR7 WLR6 WLR5 WLR4 WLR3 WLR2 WLR1
+WLR0 me84a03_HSLREF
XXWAR4L BBL7 BBL6 BBL5 BBL4 BBL3 BBL2 BBL1 BBL0 BTL7 BTL6
+BTL5 BTL4 BTL3 BTL2 BTL1 BTL0 LOG0 LOG1 RWLL RWLL me84a03_WAR4_LT
XXARRL BBL7 BBL6 BBL5 BBL4 BBL3 BBL2 BBL1 BBL0 BTL7 BTL6
+BTL5 BTL4 BTL3 BTL2 BTL1 BTL0 LOG0 WLL7 WLL6 WLL5 WLL4
+WLL3 WLL2 WLL1 WLL0 me84a03_AR4_LT
XI20 LOG0 LOG1 me84a03_CAP_LT
XXRW RWLL RWLR WRREF LOG0 LOG1 RBLRD RBLWR VDD VDD WCLKRD0 WCLKRDB0 ACUTRK
+RWLR Z2 Z1 Z0 me84a03_RW_LC
XXRIO BCBR BCTR CCOR CCRD CCWR DCLKBR LOG0 LOG1 LWER MCLK PRCHRDBR0
+PRCHRDBR1 PRCHRDBR2 PRCHRDBR3 RBLRD RBLWR NET119 NET289 SAEB SAEBRT SAOFF
+STCLK STCLKWR SWBAWTR SWBAWTBR T1B WRREF me84a03_RIO_BL
XIX8DEC WLL7 WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 WLR7 WLR6
+WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 ACUTRK NET121 NET120 WRREF Z2 Z1
+Z0 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1 PARDB0
+PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9 PBRDB8
+PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1 PBRDB0 NET291
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 me84a03_X8DEC_LC
XXIO00 BBL0 BBL1 BBL2 BBL3 BCBL BCTL BTL0 BTL1 BTL2 BTL3 CCRDL
+D0 DCLKBL LOG0 LOG1 LWEL PRCHRDBL0 PRCHRDBL1 PRCHRDBL2 PRCHRDBL3 Q0
+SAEBL SWBAWTL SWBAWTBL TD0 TWEM0 WEM0 NET392 NET124 NET392 me84a03_IOCM4_LC
XXIO01 BBL4 BBL5 BBL6 BBL7 BCBL BCTL BTL4 BTL5 BTL6 BTL7 CCRDL
+D1 DCLKBL LOG0 LOG1 LWEL PRCHRDBL0 PRCHRDBL1 PRCHRDBL2 PRCHRDBL3 Q1
+SAEBL SWBAWTL SWBAWTBL TD1 TWEM1 WEM1 NET389 NET123 NET389 me84a03_IOCM4_LC
XXIO04 BBR4 BBR5 BBR6 BBR7 BCBR BCTR BTR4 BTR5 BTR6 BTR7 CCRD
+D3 DCLKBR LOG0 LOG1 LWER PRCHRDBR0 PRCHRDBR1 PRCHRDBR2 PRCHRDBR3 Q3
+SAEB SWBAWTR SWBAWTBR TD3 TWEM3 WEM3 NET384 NET117 NET384 me84a03_IOCM4_LC
XXIO03 BBR0 BBR1 BBR2 BBR3 BCBR BCTR BTR0 BTR1 BTR2 BTR3 CCRD
+D2 DCLKBR LOG0 LOG1 LWER PRCHRDBR0 PRCHRDBR1 PRCHRDBR2 PRCHRDBR3 Q2
+SAEB SWBAWTR SWBAWTBR TD2 TWEM2 WEM2 NET395 NET118 NET395 me84a03_IOCM4_LC
XXCENTER ACUTRK BCBL BCBR BCTL BCTR CCOR CCRDL CCRD CCWR DCLKBL DCLKBR LWEL LWER
+ MCLK NET316 NET317 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2
+PARDB1 PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10
+PBRDB9 PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2
+PBRDB1 PBRDB0 PRCHRDBL3 PRCHRDBL2 PRCHRDBL1 PRCHRDBL0 PRCHRDBR3
+PRCHRDBR2 PRCHRDBR1 PRCHRDBR0 QM NET291 YA1QB YA1QT RMENB NET289 SAEBL
+SAOFF SWBAWTBL SWBAWTBR SWBAWTL SWBAWTR T1B WCLKRD1 WCLKRD0 WCLKRDB1
+WCLKRDB0 NET122 NET314 Z0B Z2 Z1 Z0 LOG0 LOG1 RM0N RM0N VDD RM0N1 RM0N
+RM1N RM1P1 RM1N RM1N VSS SAEBRT AWT BISTE CLK ME YA1QT RMDEF2 RMDEF1
+RMDEF0 RMEN RMENB RMEN RM3 RM2 RM1 RM0 RMFAST2 RMFAST1 RMFAST0
+RMSLOW2 RMSLOW1 RMSLOW0 RST NET317 STCLK STCLKWR NET314 TCLK TEST1 TME
+TWE TXA6 TXA5 TXA4 TXA3 TXA2 TXA1 TXA0 TYA1 TYA0 WE XA6
+XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0 me84a03_CENTER_LC
.ENDS me84a03_X1P11CM4_LC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X8DEC_BUF                                                            *
* LAST TIME SAVED:  MAY 08 15:22:53 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X8DEC_BUF WLL7 WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 VDDL
+WLB7 WLB6 WLB5 WLB4 WLB3 WLB2 WLB1 WLB0
*.PININFO WLL7:O WLL6:O WLL5:O WLL4:O WLL3:O WLL2:O WLL1:O WLL0:O VDDL:B
*.PININFO WLB7:I WLB6:I WLB5:I WLB4:I WLB3:I WLB2:I WLB1:I WLB0:I
XX2DEC01 VDDL WLB2 WLB3 WLL2 WLL3 me84a03_X2DEC_BUF
XX2DEC00 VDDL WLB0 WLB1 WLL0 WLL1 me84a03_X2DEC_BUF
XX2DEC02 VDDL WLB4 WLB5 WLL4 WLL5 me84a03_X2DEC_BUF
XX2DECFF VDDL WLB6 WLB7 WLL6 WLL7 me84a03_X2DEC_BUF
.ENDS me84a03_X8DEC_BUF

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_NR2PA                                                                *
* LAST TIME SAVED:  MAY 07 12:39:33 2013                                      *
*******************************************************************************
.SUBCKT me84a03_NR2PA Z A B LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD
+LP2=me84a03_LPD WN1=me84a03_WND WN2=me84a03_WND WP1=me84a03_WPD WP2=me84a03_WPD
*.PININFO Z:O A:I B:I
XMTN1 Z B VSS VSS N12_LP W=WN1 L=LN1 M=1
XMTN2 Z A VSS VSS N12_LP W=WN2 L=LN2 M=1
XMTP1 N1 B Z VDD P12_LP W=WP1 L=LP1 M=1
XMTP2 VDD A N1 VDD P12_LP W=WP2 L=LP2 M=1
XMI1 VDD A N2 VDD P12_LP W=WP2 L=LP2 M=1
XMI0 N2 B Z VDD P12_LP W=WP1 L=LP1 M=1
.ENDS me84a03_NR2PA

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_XDEC_SD                                                              *
* LAST TIME SAVED:  MAY 08 15:23:12 2014                                      *
*******************************************************************************
.SUBCKT me84a03_XDEC_SD WLB WLR WRREF ARD BRD VDDR WCLKRD WCLKRDB LN=me84a03_LND LP=me84a03_LPD
*.PININFO WLB:O WLR:O WRREF:B ARD:I BRD:I VDDR:I WCLKRD:I WCLKRDB:I
XI15 WWRD WLN WCLKRD WCLKRDB me84a03_TG WN=1.5U WP=1.0U
XI352 ABRD ARD BRD me84a03_NR2PA LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD WN1=0.38U WN2=0.38U
+WP1=0.3U WP2=0.3U
XMI500 VDD WCLKRD WLN VDD P12_LP W=1.8U L=me84a03_LD M=1
XI233 WWRD ABRD me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.0U WP=1.5U
XI23 WLT WLN me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.3U WP=2.6U
XI24 WLB WLT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=4.0U WP=8.0U
XI364 WLR WLB VSS VDDR me84a03_INV_PG LN=me84a03_LD LP=me84a03_LD WN=5U WP=10U
.ENDS me84a03_XDEC_SD

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X2DEC_SD                                                             *
* LAST TIME SAVED:  MAY 08 15:23:05 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X2DEC_SD ARD0 ARD1 BRD VDDR WCLKRD WCLKRDB0 WCLKRDB1 WLB0
+WLB1 WLR0 WLR1 WRREF LN=me84a03_LND LP=me84a03_LPD
*.PININFO ARD0:I ARD1:I BRD:I VDDR:I WCLKRD:I WCLKRDB0:I WCLKRDB1:I WLB0:O
*.PININFO WLB1:O WLR0:O WLR1:O WRREF:B
XXDECFF WLB1 WLR1 WRREF ARD1 BRD VDDR WCLKRD WCLKRDB1 me84a03_XDEC_SD
XXDEC00 WLB0 WLR0 WRREF ARD0 BRD VDDR WCLKRD WCLKRDB0 me84a03_XDEC_SD
.ENDS me84a03_X2DEC_SD

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X8DEC_SD                                                             *
* LAST TIME SAVED:  MAY 08 15:22:53 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X8DEC_SD WLB7 WLB6 WLB5 WLB4 WLB3 WLB2 WLB1 WLB0 WLR7
+WLR6 WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 ACUTRK VDDR WRREF Z2 Z1
+Z0 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1 PARDB0
+PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9 PBRDB8
+PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1 PBRDB0
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 LN=me84a03_LND LP=me84a03_LPD
*.PININFO WLB7:O WLB6:O WLB5:O WLB4:O WLB3:O WLB2:O WLB1:O WLB0:O WLR7:O
*.PININFO WLR6:O WLR5:O WLR4:O WLR3:O WLR2:O WLR1:O WLR0:O ACUTRK:B VDDR:B
*.PININFO WRREF:B Z2:B Z1:B Z0:B PARDB7:I PARDB6:I PARDB5:I PARDB4:I
*.PININFO PARDB3:I PARDB2:I PARDB1:I PARDB0:I PBRDB15:I PBRDB14:I PBRDB13:I
*.PININFO PBRDB12:I PBRDB11:I PBRDB10:I PBRDB9:I PBRDB8:I PBRDB7:I PBRDB6:I
*.PININFO PBRDB5:I PBRDB4:I PBRDB3:I PBRDB2:I PBRDB1:I PBRDB0:I WCLKRD1:I
*.PININFO WCLKRD0:I WCLKRDB1:I WCLKRDB0:I
XX2DEC01 PARDB2 PARDB3 PBRDB0 VDDR WCLKRD0 WCLKRDB0 WCLKRDB1 WLB2
+WLB3 WLR2 WLR3 WRREF me84a03_X2DEC_SD
XX2DEC00 PARDB0 PARDB1 PBRDB0 VDDR WCLKRD0 WCLKRDB0 WCLKRDB1 WLB0
+WLB1 WLR0 WLR1 WRREF me84a03_X2DEC_SD
XX2DEC02 PARDB4 PARDB5 PBRDB0 VDDR WCLKRD1 WCLKRDB0 WCLKRDB1 WLB4
+WLB5 WLR4 WLR5 WRREF me84a03_X2DEC_SD
XX2DECFF PARDB6 PARDB7 PBRDB0 VDDR WCLKRD1 WCLKRDB0 WCLKRDB1 WLB6
+WLB7 WLR6 WLR7 WRREF me84a03_X2DEC_SD
.ENDS me84a03_X8DEC_SD

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X8DEC                                                                *
* LAST TIME SAVED:  MAY 08 15:23:01 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X8DEC WLL7 WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 WLR7
+WLR6 WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 ACUTRK VDDL VDDR WRREF Z2
+Z1 Z0 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1
+PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9
+PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1
+PBRDB0 WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 LN=me84a03_LND LP=me84a03_LPD
*.PININFO WLL7:O WLL6:O WLL5:O WLL4:O WLL3:O WLL2:O WLL1:O WLL0:O WLR7:O
*.PININFO WLR6:O WLR5:O WLR4:O WLR3:O WLR2:O WLR1:O WLR0:O ACUTRK:B VDDL:B
*.PININFO VDDR:B WRREF:B Z2:B Z1:B Z0:B PARDB7:I PARDB6:I PARDB5:I PARDB4:I
*.PININFO PARDB3:I PARDB2:I PARDB1:I PARDB0:I PBRDB15:I PBRDB14:I PBRDB13:I
*.PININFO PBRDB12:I PBRDB11:I PBRDB10:I PBRDB9:I PBRDB8:I PBRDB7:I PBRDB6:I
*.PININFO PBRDB5:I PBRDB4:I PBRDB3:I PBRDB2:I PBRDB1:I PBRDB0:I WCLKRD1:I
*.PININFO WCLKRD0:I WCLKRDB1:I WCLKRDB0:I
XI20 WLL7 WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 VDDL NET467
+NET466 NET465 NET464 NET463 NET462 NET461 NET460 me84a03_X8DEC_BUF
XI19 NET467 NET466 NET465 NET464 NET463 NET462 NET461 NET460
+WLR7 WLR6 WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 ACUTRK VDDR WRREF Z2
+Z1 Z0 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1
+PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9
+PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1
+PBRDB0 WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 me84a03_X8DEC_SD
.ENDS me84a03_X8DEC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RD                                                                   *
* LAST TIME SAVED:  MAY 08 15:22:58 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RD WLB WLR LOG0 LOG1 VDDR WCLKRD WCLKRDB LN=me84a03_LND LP=me84a03_LPD
*.PININFO WLB:O WLR:O LOG0:B LOG1:B VDDR:B WCLKRD:I WCLKRDB:I
XI9 WLR WLB VSS VDDR me84a03_INV_PG LN=me84a03_LD LP=me84a03_LD WN=5.0U WP=10.0U
XI10 WWRD LOG1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.5U WP=1.0U
XI23 WLT WLN me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.3U WP=2.6U
XI24 WLB WLT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=4.0U WP=8.0U
XMI6 VDD WCLKRD WLN VDD P12_LP W=3.52U L=me84a03_LD M=1
XI3 WWRD WLN WCLKRD WCLKRDB me84a03_TG WN=2.5U WP=1.0U
.ENDS me84a03_RD

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RW_SD                                                                *
* LAST TIME SAVED:  MAY 08 15:22:58 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RW_SD ACUTRK LOG0 LOG1 RBLRD RBLWR RWLDR RWLR VDDR WCLKRD WCLKRDB WLB
+WRREF Z0 Z1 Z2 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO ACUTRK:I LOG0:B LOG1:B RBLRD:B RBLWR:B RWLDR:I RWLR:O VDDR:B WCLKRD:B WCLKRDB:B
*.PININFO WLB:O WRREF:O Z0:I Z1:I Z2:I
XRD WLB RWLR LOG0 LOG1 VDDR WCLKRD WCLKRDB me84a03_RD
XI9 WRREF RBB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.01U
XI523 BUF_WCLKRD NET094 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.25U WP=1.0U
XI39 NET094 WCLKRD me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI4 RBLWR RB ACUTRK RWLDR WCLKRD me84a03_RAM6X_XPM_WK
XMI24 VDD RWLDR RBLRD VDD P12_LP W=4.0U L=me84a03_LD M=1
XMI185 VDD LOG0 LOG1 VDD P12_LP W=2.4U L=me84a03_LD M=1
XMI27 VDD BUF_WCLKRD NET089 VDD P12_LP W=0.3U L=me84a03_LD M=1
XMI32 RBLRD RWLDR NET34 VSS NPG W=W1PG L=L1PG M=4
XMI33 NET52 Z1 NET089 VSS NPD W=W1PD L=L1PD M=6
XMI34 RBLRD RWLDR NET52 VSS NPG W=W1PG L=L1PG M=6
XMI35 RBLRD RWLDR NET43 VSS NPG W=W1PG L=L1PG M=2
XMI36 NET43 LOG1 NET089 VSS NPD W=W1PD L=L1PD M=2
XMI31 NET34 Z0 NET089 VSS NPD W=W1PD L=L1PD M=4
XMI37 RBLRD RWLDR NET28 VSS NPG W=W1PG L=L1PG M=12
XMI38 NET28 Z2 NET089 VSS NPD W=W1PD L=L1PD M=12
XMI186 VSS LOG1 LOG0 VSS N12_LP W=0.6U L=me84a03_LD M=1
XMI25 NET089 BUF_WCLKRD VSS VSS N12_LP W=6.0U L=me84a03_LD M=1
XXRB RBB RB WCLKRD me84a03_ND2 LN1=me84a03_LND WN1=0.8U WN2=1.05U WP1=0.15U WP2=0.60U
.ENDS me84a03_RW_SD

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RW                                                                   *
* LAST TIME SAVED:  MAY 08 15:23:13 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RW RWLL RWLR WRREF LOG0 LOG1 RBLRD RBLWR VDDL VDDR WCLKRD WCLKRDB ACUTRK
+ RWLDR Z2 Z1 Z0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO RWLL:O RWLR:O WRREF:O LOG0:B LOG1:B RBLRD:B RBLWR:B VDDL:B VDDR:B WCLKRD:B
*.PININFO WCLKRDB:B ACUTRK:I RWLDR:I Z2:I Z1:I Z0:I
XI43 VDDL NET53 RWLL me84a03_RD_BUF
XI42 ACUTRK LOG0 LOG1 RBLRD RBLWR RWLDR RWLR VDDR WCLKRD WCLKRDB NET53 WRREF
+Z0 Z1 Z2 me84a03_RW_SD
.ENDS me84a03_RW

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM4_LITE                                                           *
* LAST TIME SAVED:  MAY 08 15:23:04 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM4_LITE BB0 BB1 BB2 BB3 BT0 BT1 BT2 BT3 CCRD DA DCLKB
+ LOG0 LOG1 LWE PCB0 PCB1 PCB2 PCB3 Q SAEB WEMA WEMA_AH WEMA_AL WEMA_IN
+LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BB2:B BB3:B BT0:B BT1:B BT2:B BT3:B CCRD:I DA:I
*.PININFO DCLKB:I LOG0:B LOG1:B LWE:I PCB0:B PCB1:B PCB2:B PCB3:B Q:O SAEB:I
*.PININFO WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
XI37 NET042 LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
DI30 VSS WEMA NDIO12_LP AREA=ARD PJ=PRD
DI29 VSS DA NDIO12_LP AREA=ARD PJ=PRD
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET038 CCRD me84a03_LSA1
XXDO NET30 Q WEMA_AH WEMA_AL DA LQT WEMA me84a03_DO_LITE
XXMX BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 RDB RDT WRB WRT PCB3
+PCB2 PCB1 PCB0 me84a03_CMUX4
XXDI WRB WRT DCLKB NET30 LWE WEMA_IN me84a03_WRDRV_LITE
XI36 NET038 SAEB NET042 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM4_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DEC2TO1                                                              *
* LAST TIME SAVED:  MAY 08 15:23:09 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DEC2TO1 Q D0 D1 PRCLK
*.PININFO Q:O D0:I D1:I PRCLK:I
XI81 Q DD me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=3.5U WP=7.0U
XI63 DD PRCLK D0 D1 me84a03_ND3 LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=2.0U WN2=2.0U WN3=2.0U
+WP1=1.5U WP2=1.5U WP3=1.5U
.ENDS me84a03_DEC2TO1

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CBUF_LITE                                                            *
* LAST TIME SAVED:  MAY 08 15:23:05 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CBUF_LITE CCRDL CSHARE DCLKBL FLOATI LA0QB LA0QT LA1QB LWEI LWEL
+PRCHBL0 PRCHBL1 PRCHBL2 PRCHBL3 PRCLK SAEBL SAEBRT SAOFF
*.PININFO CCRDL:O CSHARE:I DCLKBL:O FLOATI:I LA0QB:I LA0QT:I LA1QB:I LWEI:I LWEL:O
*.PININFO PRCHBL0:O PRCHBL1:O PRCHBL2:O PRCHBL3:O PRCLK:I SAEBL:O SAEBRT:I SAOFF:I
XI131 PRCHBL3 LA0QT CSHARE PRCLK me84a03_DEC2TO1
XI130 PRCHBL2 LA0QB CSHARE PRCLK me84a03_DEC2TO1
XI129 PRCHBL1 LA0QT LA1QB PRCLK me84a03_DEC2TO1
XI128 PRCHBL0 LA0QB LA1QB PRCLK me84a03_DEC2TO1
XI54 LWEL LWEI me84a03_INV LN=me84a03_LD LP=0.06U WN=3U WP=6U
XI0 CCRDL SAOFF me84a03_INV LN=me84a03_LD LP=0.06U WN=3U WP=6U
XI55 DCLKBL FLOATI me84a03_INV LN=0.06U LP=me84a03_LD WN=3U WP=6U
XI23 SAEBL SAEBRT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=8.8U WP=5.2U
.ENDS me84a03_CBUF_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ADRLAT                                                               *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_ADRLAT QB QT A CB CT LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO QB:O QT:O A:I CB:I CT:I
XMI133 PA CT QB VDD P12_LP W=2U L=me84a03_LD M=1
XMI132 VDD A PA VDD P12_LP W=2U L=me84a03_LD M=1
XI1 QB QT CT CB me84a03_CINV LN1=me84a03_LD LN2=me84a03_LD LP1=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U WP1=0.15U
+WP2=0.15U
XMI135 VSS A NA VSS N12_LP W=1U L=me84a03_LD M=1
XMI134 NA CB QB VSS N12_LP W=1U L=me84a03_LD M=1
XI137 QT QB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
.ENDS me84a03_ADRLAT

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DEC4TO1B                                                             *
* LAST TIME SAVED:  MAY 08 15:23:00 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DEC4TO1B QB D0 D1 D2 D3
*.PININFO QB:O D0:I D1:I D2:I D3:I
XI94 QT DD me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.28U WP=0.56U
XI0 QB QT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.41U WP=2.79U
XI63 DD D3 D2 D1 D0 me84a03_ND4 LN1=me84a03_LD LN2=me84a03_LD
+LN3=me84a03_LND LN4=me84a03_LND LP1=me84a03_LD LP2=me84a03_LD LP3=me84a03_LPD LP4=me84a03_LPD
+ WN1=0.3U WN2=0.3U WN3=0.3U WN4=0.3U WP1=0.15U WP2=0.15U WP3=0.15U WP4=0.15U
.ENDS me84a03_DEC4TO1B

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_PR16B                                                                *
* LAST TIME SAVED:  MAY 08 15:22:53 2014                                      *
*******************************************************************************
.SUBCKT me84a03_PR16B QB15 QB14 QB13 QB12 QB11 QB10 QB9 QB8 QB7 QB6
+QB5 QB4 QB3 QB2 QB1 QB0 A3 A2 A1 A0 CB CT LN1=me84a03_LND LN2=me84a03_LND
+LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO QB15:O QB14:O QB13:O QB12:O QB11:O QB10:O QB9:O QB8:O QB7:O
*.PININFO QB6:O QB5:O QB4:O QB3:O QB2:O QB1:O QB0:O A3:I A2:I A1:I
*.PININFO A0:I CB:I CT:I
XI390 LA3QB LA3QT A3 CB CT me84a03_ADRLAT
XI216 LA2QB LA2QT A2 CB CT me84a03_ADRLAT
XI168 LA1QB LA1QT A1 CB CT me84a03_ADRLAT
XI165 LA0QB LA0QT A0 CB CT me84a03_ADRLAT
XI335 QB8 LA0QB LA1QB LA2QB LA3QT me84a03_DEC4TO1B
XI336 QB14 LA0QB LA1QT LA2QT LA3QT me84a03_DEC4TO1B
XI337 QB12 LA0QB LA1QB LA2QT LA3QT me84a03_DEC4TO1B
XI339 QB10 LA0QB LA1QT LA2QB LA3QT me84a03_DEC4TO1B
XI340 QB9 LA0QT LA1QB LA2QB LA3QT me84a03_DEC4TO1B
XI345 QB15 LA0QT LA1QT LA2QT LA3QT me84a03_DEC4TO1B
XI346 QB13 LA0QT LA1QB LA2QT LA3QT me84a03_DEC4TO1B
XI347 QB11 LA0QT LA1QT LA2QB LA3QT me84a03_DEC4TO1B
XI131 QB3 LA0QT LA1QT LA2QB LA3QB me84a03_DEC4TO1B
XI207 QB5 LA0QT LA1QB LA2QT LA3QB me84a03_DEC4TO1B
XI205 QB7 LA0QT LA1QT LA2QT LA3QB me84a03_DEC4TO1B
XI129 QB1 LA0QT LA1QB LA2QB LA3QB me84a03_DEC4TO1B
XI130 QB2 LA0QB LA1QT LA2QB LA3QB me84a03_DEC4TO1B
XI200 QB4 LA0QB LA1QB LA2QT LA3QB me84a03_DEC4TO1B
XI206 QB6 LA0QB LA1QT LA2QT LA3QB me84a03_DEC4TO1B
XI307 QB0 LA0QB LA1QB LA2QB LA3QB me84a03_DEC4TO1B
.ENDS me84a03_PR16B

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_PR4                                                                  *
* LAST TIME SAVED:  MAY 08 15:23:00 2014                                      *
*******************************************************************************
.SUBCKT me84a03_PR4 LA0QB LA0QT LA1QB LA1QT PRCHBR3 PRCHBR2 PRCHBR1 PRCHBR0 A0
+A1 CB CSHARE CT PRCLK LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO LA0QB:O LA0QT:O LA1QB:O LA1QT:O PRCHBR3:O PRCHBR2:O PRCHBR1:O PRCHBR0:O
*.PININFO A0:I A1:I CB:I CSHARE:I CT:I PRCLK:I
XI168 LA1QB LA1QT A1 CB CT me84a03_ADRLAT
XI165 LA0QB LA0QT A0 CB CT me84a03_ADRLAT
XI128 PRCHBR0 LA0QB LA1QB PRCLK me84a03_DEC2TO1
XI129 PRCHBR1 LA0QT LA1QB PRCLK me84a03_DEC2TO1
XI130 PRCHBR2 LA0QB CSHARE PRCLK me84a03_DEC2TO1
XI131 PRCHBR3 LA0QT CSHARE PRCLK me84a03_DEC2TO1
.ENDS me84a03_PR4

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_DEC3TO1B                                                             *
* LAST TIME SAVED:  MAY 08 15:22:59 2014                                      *
*******************************************************************************
.SUBCKT me84a03_DEC3TO1B QB D0 D1 D2
*.PININFO QB:O D0:I D1:I D2:I
XI523 QT DD me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.6U
XXQB QB QT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.1U WP=2.2U
XI63 DD D2 D1 D0 me84a03_ND3 LN1=me84a03_LD LN2=me84a03_LD LN3=me84a03_LND
+LP1=me84a03_LD LP2=me84a03_LD LP3=me84a03_LPD WN1=0.15U WN2=0.15U
+ WN3=0.15U WP1=0.15U WP2=0.15U WP3=0.15U
.ENDS me84a03_DEC3TO1B

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_PR8B                                                                 *
* LAST TIME SAVED:  MAY 08 15:23:06 2014                                      *
*******************************************************************************
.SUBCKT me84a03_PR8B LA0QB LA0QT QB7 QB6 QB5 QB4 QB3 QB2 QB1 QB0 A2
+A1 A0 CB CT LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO LA0QB:O LA0QT:O QB7:O QB6:O QB5:O QB4:O QB3:O QB2:O QB1:O QB0:O
*.PININFO A2:I A1:I A0:I CB:I CT:I
XI216 LA2QB LA2QT A2 CB CT me84a03_ADRLAT
XI168 LA1QB LA1QT A1 CB CT me84a03_ADRLAT
XI165 LA0QB LA0QT A0 CB CT me84a03_ADRLAT
XI131 QB3 LA0QT LA1QT LA2QB me84a03_DEC3TO1B
XI207 QB5 LA0QT LA1QB LA2QT me84a03_DEC3TO1B
XI205 QB7 LA0QT LA1QT LA2QT me84a03_DEC3TO1B
XI129 QB1 LA0QT LA1QB LA2QB me84a03_DEC3TO1B
XI130 QB2 LA0QB LA1QT LA2QB me84a03_DEC3TO1B
XI200 QB4 LA0QB LA1QB LA2QT me84a03_DEC3TO1B
XI206 QB6 LA0QB LA1QT LA2QT me84a03_DEC3TO1B
XI307 QB0 LA0QB LA1QB LA2QB me84a03_DEC3TO1B
.ENDS me84a03_PR8B

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ADRGEN                                                               *
* LAST TIME SAVED:  MAY 08 15:23:07 2014                                      *
*******************************************************************************
.SUBCKT me84a03_ADRGEN LYA0QB LYA0QT LYA1QB LYA1QT PAB7 PAB6 PAB5 PAB4 PAB3
+PAB2 PAB1 PAB0 PBB15 PBB14 PBB13 PBB12 PBB11 PBB10 PBB9
+PBB8 PBB7 PBB6 PBB5 PBB4 PBB3 PBB2 PBB1 PBB0 PRCHBR3
+PRCHBR2 PRCHBR1 PRCHBR0 CSHARE LCLKB LCLKT PRCLK QXA6 QXA5 QXA4
+QXA3 QXA2 QXA1 QXA0 QYA1 QYA0 LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO LYA0QB:O LYA0QT:O LYA1QB:O LYA1QT:O PAB7:O PAB6:O PAB5:O PAB4:O PAB3:O
*.PININFO PAB2:O PAB1:O PAB0:O PBB15:O PBB14:O PBB13:O PBB12:O PBB11:O
*.PININFO PBB10:O PBB9:O PBB8:O PBB7:O PBB6:O PBB5:O PBB4:O PBB3:O
*.PININFO PBB2:O PBB1:O PBB0:O PRCHBR3:O PRCHBR2:O PRCHBR1:O PRCHBR0:O
*.PININFO CSHARE:I LCLKB:I LCLKT:I PRCLK:I QXA6:I QXA5:I QXA4:I QXA3:I QXA2:I
*.PININFO QXA1:I QXA0:I QYA1:I QYA0:I
XXB PBB15 PBB14 PBB13 PBB12 PBB11 PBB10 PBB9 PBB8 PBB7 PBB6
+PBB5 PBB4 PBB3 PBB2 PBB1 PBB0 QXA6 QXA5 QXA4 QXA3 LCLKB
+LCLKT me84a03_PR16B
XXYM LYA0QB LYA0QT LYA1QB LYA1QT PRCHBR3 PRCHBR2 PRCHBR1 PRCHBR0 QYA0
+QYA1 LCLKB CSHARE LCLKT PRCLK me84a03_PR4
XIXA RPAB1 RPAB0 PAB7 PAB6 PAB5 PAB4 PAB3 PAB2 PAB1 PAB0
+QXA2 QXA1 QXA0 LCLKB LCLKT me84a03_PR8B
.ENDS me84a03_ADRGEN

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_WCLKBUF                                                              *
* LAST TIME SAVED:  MAY 08 15:23:11 2014                                      *
*******************************************************************************
.SUBCKT me84a03_WCLKBUF WCLK1 WCLK0 WCLKB1 WCLKB0 WCT
*.PININFO WCLK1:O WCLK0:O WCLKB1:O WCLKB0:O WCT:I
XI11 WCLK1 WB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=8.0U WP=16.0U
XI4 WCLK0 RFLOATT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=8.0U WP=16.0U
XI12 RFLOATT WCT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.0U WP=4.0U
XI14 WCLKB0 WCLK0 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.0U WP=6.0U
XI13 WCLKB1 WCLK1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.0U WP=6.0U
XI19 WB WCT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.0U WP=4.0U
.ENDS me84a03_WCLKBUF

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CCBUF                                                                *
* LAST TIME SAVED:  MAY 08 15:23:02 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CCBUF CCRDR SAPRB SAOFF
*.PININFO CCRDR:O SAPRB:O SAOFF:I
XI409 CCRDR SAPRB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2U WP=6U
XI355 SAPRT SAOFF me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.6U
XI410 SAPRB SAPRT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.0U WP=1.5U
.ENDS me84a03_CCBUF

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CENRD_LITE                                                           *
* LAST TIME SAVED:  MAY 08 15:22:54 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CENRD_LITE CCOR CCRDR CCWR DCLKBR FLOATI LCLKB LCLKT PRCLKRD RDOFF SAOFF
+ WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 FLOAT CLK LME LWE MCLK MET RST STCLK
+ STCLKWR T1B LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO CCOR:O CCRDR:O CCWR:O DCLKBR:O FLOATI:O LCLKB:O LCLKT:O PRCLKRD:O RDOFF:O
*.PININFO SAOFF:O WCLKRD1:O WCLKRD0:O WCLKRDB1:O WCLKRDB0:O FLOAT:B CLK:I LME:I
*.PININFO LWE:I MCLK:I MET:I RST:I STCLK:I STCLKWR:I T1B:I
XI60 CCWR CCWRB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI19 LCLKB LCLKT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.5U WP=4.5U
XI32 LWEB LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.3U
XI8 NET098 LMELCLKB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.7U WP=1.4U
XI45 FBR FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.3U
XI29 LMECT LMECB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI44 FBW FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI34 CCOR CCORB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI37 FLOATI FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.0U WP=4.0U
XI35 DCLKBR FLOATI me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=3.0U WP=6.0U
XI50 LMECB FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI46 RDOFF NET098 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=4U WP=4U
XI48 PRCLKRD FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=4U WP=5U
XXWC WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 WCTRD me84a03_WCLKBUF
XI915 FLOAT WCTRD CLK LME MCLK RST STCLK STCLKWR T1B me84a03_CLOCK_LITE
XI15 CCRDR SAOFF CCORB me84a03_CCBUF
XI24 LMELCLKB LMECT LMECB MET me84a03_L0B
XI61 CCWRB FBW LWE T1B me84a03_ND3 WN1=0.5U WN2=0.5U WN3=0.5U WP1=0.5U WP2=0.5U WP3=0.5U
XI43 CCORB FBR LWEB me84a03_ND2 WN1=1.0U WN2=1.0U WP1=1.0U WP2=1.0U
XI49 LCLKT FLOAT MET me84a03_ND2 WN1=3.0U WN2=3.0U WP1=3.0U WP2=1.0U
.ENDS me84a03_CENRD_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RM4TO1                                                               *
* LAST TIME SAVED:  MAY 08 15:23:07 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RM4TO1 Z ZB A B C D SA SB0 SB1 SC0 SC1 SD0 SD1 LN=me84a03_LND LP=me84a03_LPD
*.PININFO Z:O ZB:O A:I B:I C:I D:I SA:I SB0:I SB1:I SC0:I SC1:I SD0:I SD1:I
XI3 Z ZB me84a03_INV WN=0.2U WP=0.4U
XI2 ZB NET33 me84a03_INV WN=0.2U WP=0.4U
XMI1 A SA NET33 VSS N12_LP W=0.2U L=me84a03_LND M=1
XIQ5 C NET33 SC1 SC0 me84a03_TG WN=0.2U WP=0.2U
XIQ6 D NET33 SD1 SD0 me84a03_TG WN=0.2U WP=0.2U
XIQ4 B NET33 SB1 SB0 me84a03_TG WN=0.2U WP=0.2U
.ENDS me84a03_RM4TO1

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RM2TO4                                                               *
* LAST TIME SAVED:  MAY 08 15:23:10 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RM2TO4 RMENB SEL001 SEL000 SEL011 SEL010 SEL101 SEL100
+SEL111 SEL110 PRM04 PRM03 PRM02 PRM01 PRM00 PRM14 PRM13
+PRM12 PRM11 PRM10 RM1 RM0 RMEN RMENI1 RMENI0 LN1=me84a03_LND LN2=me84a03_LND LP1=me84a03_LPD
+ LP2=me84a03_LPD
*.PININFO RMENB:O SEL001:O SEL000:O SEL011:O SEL010:O SEL101:O SEL100:O
*.PININFO SEL111:O SEL110:O PRM04:B PRM03:B PRM02:B PRM01:B PRM00:B
*.PININFO PRM14:B PRM13:B PRM12:B PRM11:B PRM10:B RM1:I RM0:I RMEN:I
*.PININFO RMENI1:I RMENI0:I
XMI21 PRM01 RMENI0 PRM00 VSS N12_LP W=0.2U L=me84a03_LND M=1
XMI20 PRM01 RM0 VSS VSS N12_LP W=0.2U L=me84a03_LND M=1
XMI41 PRM11 RMENI1 PRM10 VSS N12_LP W=0.2U L=me84a03_LND M=1
XMI42 PRM11 RM1 VSS VSS N12_LP W=0.2U L=me84a03_LND M=1
XMI19 PRM02 RMENI0 PRM03 VDD P12_LP W=0.2U L=me84a03_LPD M=1
XMI18 VDD RM0 PRM03 VDD P12_LP W=0.2U L=me84a03_LPD M=1
XMI40 PRM12 RMENI1 PRM13 VDD P12_LP W=0.2U L=me84a03_LPD M=1
XMI39 VDD RM1 PRM13 VDD P12_LP W=0.2U L=me84a03_LPD M=1
XI25 A PRM04 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI989 SEL111 SEL110 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI963 SEL001 SEL000 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI948 SEL101 SEL100 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI951 SEL011 SEL010 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI43 B PRM14 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI17 RMENB RMEN me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.2U
XI4 SEL110 B A me84a03_ND2 WN1=0.2U WN2=0.2U WP1=0.2U WP2=0.2U
XI3 SEL100 B PRM04 me84a03_ND2 WN1=0.2U WN2=0.2U WP1=0.2U WP2=0.2U
XI1 SEL000 PRM14 PRM04 me84a03_ND2 WN1=0.2U WN2=0.2U WP1=0.2U WP2=0.2U
XI2 SEL010 PRM14 A me84a03_ND2 WN1=0.2U WN2=0.2U WP1=0.2U WP2=0.2U
.ENDS me84a03_RM2TO4

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RMMX                                                                 *
* LAST TIME SAVED:  MAY 08 15:22:55 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RMMX ACUTRK RMENB RW_RBL Z0B Z2 Z1 Z0 PRM04 PRM03 PRM02
+PRM01 PRM00 PRM14 PRM13 PRM12 PRM11 PRM10 RMDEF2 RMDEF1
+RMDEF0 RMEN RMENI1 RMENI0 RMEXT3 RMEXT2 RMEXT1 RMEXT0 RMFAST2
+RMFAST1 RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD
+ LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO ACUTRK:O RMENB:O RW_RBL:O Z0B:O Z2:O Z1:O Z0:O PRM04:B PRM03:B
*.PININFO PRM02:B PRM01:B PRM00:B PRM14:B PRM13:B PRM12:B PRM11:B PRM10:B
*.PININFO RMDEF2:I RMDEF1:I RMDEF0:I RMEN:I RMENI1:I RMENI0:I RMEXT3:I
*.PININFO RMEXT2:I RMEXT1:I RMEXT0:I RMFAST2:I RMFAST1:I RMFAST0:I RMSLOW2:I
*.PININFO RMSLOW1:I RMSLOW0:I
DI30 VSS RMEXT3 NDIO12_LP AREA=ARD PJ=PRD
DI27 VSS RMEXT2 NDIO12_LP AREA=ARD PJ=PRD
DI37 VSS RMEXT0 NDIO12_LP AREA=ARD PJ=PRD
DI26 VSS RMEXT1 NDIO12_LP AREA=ARD PJ=PRD
DI31 VSS RMEN NDIO12_LP AREA=ARD PJ=PRD
XI3 Z1 NET0109 VSS RMSLOW1 RMDEF1 RMFAST1 SA1 SB0 SB1 SC0 SC1
+SD0 SD1 me84a03_RM4TO1
XI4 Z2 NET099 VSS RMSLOW2 RMDEF2 RMFAST2 SA1 SB0 SB1 SC0 SC1
+SD0 SD1 me84a03_RM4TO1
XI2 Z0 Z0B VSS RMSLOW0 RMDEF0 RMFAST0 SA1 SB0 SB1 SC0 SC1
+SD0 SD1 me84a03_RM4TO1
XI1 RMENB SA1 SA0 SB1 SB0 SC1 SC0 SD1 SD0 PRM04 PRM03
+PRM02 PRM01 PRM00 PRM14 PRM13 PRM12 PRM11 PRM10 RMEXT1
+RMEXT0 RMEN RMENI1 RMENI0 me84a03_RM2TO4
XI43 ACUTRK SC0 SD0 me84a03_ND2 WN1=0.4U WN2=0.4U WP1=0.4U WP2=0.4U
XI33 NET063 RMEXT2 RMEN me84a03_ND2 WN1=0.2U WN2=0.2U WP1=0.2U WP2=0.2U
XI40 RW_RBL SB0 SA0 NET063 me84a03_ND3 WN1=0.2U WN2=0.2U WN3=0.2U WP1=0.2U WP2=0.2U
+WP3=0.2U
.ENDS me84a03_RMMX

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CTRL_LITE                                                            *
* LAST TIME SAVED:  MAY 08 15:22:57 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CTRL_LITE LME LWE LWEI LWER MCLK MERDA0 MERDA1 METRD T1B WEA0 WEA1 CB
+CLK CT ME SMERD SWE TEST1 WE LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO LME:O LWE:O LWEI:O LWER:O MCLK:O MERDA0:O MERDA1:O METRD:O T1B:O WEA0:O WEA1:O
*.PININFO CB:I CLK:I CT:I ME:I SMERD:I SWE:I TEST1:I WE:I
XI43 METRDB SMERD me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.5U WP=1.0U
XI62 MERDA1 MERDA0 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.7U
XI61 MERDA0 ME me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.7U
XI60 WEA0 WE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.7U
XI57 LWEI LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.8U WP=1.5U
XI19 MCLKT MCLKB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.7U
XI149 METRD METRDB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI59 WEA1 WEA0 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.7U
XI26 T1B TEST1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.4U
XI54 LWER LWEI me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=3.0U WP=6.0U
XI64 MCLK MCLKB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.0U WP=8.0U
XI63 MCLKB CLK me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=3.2U WP=3.2U
XXLWE LWE CB CT METWRB me84a03_L0B
XXLME LME MCLKB MCLKT METRDB me84a03_L1B
DI69 VSS WE NDIO12_LP AREA=ARD PJ=PRD
DI68 VSS ME NDIO12_LP AREA=ARD PJ=PRD
DI0 VSS TEST1 NDIO12_LP AREA=ARD PJ=PRD
DI65 VSS CLK NDIO12_LP AREA=ARD PJ=PRD
XI58 METWRB SWE SMERD me84a03_ND2 WN1=0.7U WN2=0.7U WP1=0.7U WP2=0.7U
.ENDS me84a03_CTRL_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CENTER_SD_LITE                                                       *
* LAST TIME SAVED:  MAY 08 15:23:10 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CENTER_SD_LITE ACUTRK CCOR CCRDR CCWR CLK DCLKBR FLOATI LOG0 LOG1 LWEI
+LWER MCLK ME MERDA0 MERDA1 PARDB0 PARDB1 PARDB2 PARDB3 PARDB4
+PARDB5 PARDB6 PARDB7 PBRDB0 PBRDB1 PBRDB10 PBRDB11 PBRDB12
+PBRDB13 PBRDB14 PBRDB15 PBRDB2 PBRDB3 PBRDB4 PBRDB5 PBRDB6
+PBRDB7 PBRDB8 PBRDB9 PCBR0 PCBR1 PCBR2 PCBR3 PRCLKRD PRM00
+PRM01 PRM02 PRM03 PRM04 PRM10 PRM11 PRM12 PRM13 PRM14 RCSHARE
+ RDOFF RLYA0QB RLYA0QT RLYA1QB RLYA1QT RMDEF0 RMDEF1 RMDEF2 RMEN RMENB
+RMENI0 RMENI1 RMEXT0 RMEXT1 RMEXT2 RMEXT3 RMFAST0 RMFAST1
+RMFAST2 RMSLOW0 RMSLOW1 RMSLOW2 RST RW_RBL SAEBRT SAOFF SMERD STCLK
+STCLKWR SWE T1B TEST1 WCLKRD0 WCLKRD1 WCLKRDB0 WCLKRDB1 WE WEA0 WEA1
+XARD0 XARD1 XARD2 XARD3 XARD4 XARD5 XARD6 YARD0 YARD1 Z0
+Z0B Z1 Z2 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO ACUTRK:O CCOR:O CCRDR:O CCWR:O CLK:I DCLKBR:O FLOATI:O LOG0:B LOG1:B LWEI:O
*.PININFO LWER:O MCLK:O ME:I MERDA0:O MERDA1:O PARDB0:O PARDB1:O PARDB2:O PARDB3:O
*.PININFO PARDB4:O PARDB5:O PARDB6:O PARDB7:O PBRDB0:O PBRDB1:O PBRDB10:O
*.PININFO PBRDB11:O PBRDB12:O PBRDB13:O PBRDB14:O PBRDB15:O PBRDB2:O
*.PININFO PBRDB3:O PBRDB4:O PBRDB5:O PBRDB6:O PBRDB7:O PBRDB8:O PBRDB9:O
*.PININFO PCBR0:O PCBR1:O PCBR2:O PCBR3:O PRCLKRD:O PRM00:B PRM01:B PRM02:B
*.PININFO PRM03:B PRM04:B PRM10:B PRM11:B PRM12:B PRM13:B PRM14:B RCSHARE:I
*.PININFO RDOFF:O RLYA0QB:O RLYA0QT:O RLYA1QB:O RLYA1QT:O RMDEF0:I RMDEF1:I RMDEF2:I
*.PININFO RMEN:I RMENB:O RMENI0:I RMENI1:I RMEXT0:I RMEXT1:I RMEXT2:I RMEXT3:I
*.PININFO RMFAST0:I RMFAST1:I RMFAST2:I RMSLOW0:I RMSLOW1:I RMSLOW2:I RST:I
*.PININFO RW_RBL:O SAEBRT:B SAOFF:O SMERD:I STCLK:I STCLKWR:I SWE:I T1B:O TEST1:I
*.PININFO WCLKRD0:O WCLKRD1:O WCLKRDB0:O WCLKRDB1:O WE:I WEA0:O WEA1:O XARD0:I
*.PININFO XARD1:I XARD2:I XARD3:I XARD4:I XARD5:I XARD6:I YARD0:I YARD1:I
*.PININFO Z0:O Z0B:O Z1:O Z2:O
XXADRD RLYA0QB RLYA0QT RLYA1QB RLYA1QT PARDB7 PARDB6 PARDB5 PARDB4
+PARDB3 PARDB2 PARDB1 PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12
+PBRDB11 PBRDB10 PBRDB9 PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4
+PBRDB3 PBRDB2 PBRDB1 PBRDB0 PCBR3 PCBR2 PCBR1 PCBR0 RCSHARE
+LCLKBRD LCLKTRD PRCLKRD QXARD6 QXARD5 QXARD4 QXARD3 QXARD2 QXARD1
+QXARD0 QYARD1 QYARD0 me84a03_ADRGEN
XI37 LOG0 me84a03_LOG
XXCENRD CCOR CCRDR CCWR DCLKBR FLOATI LCLKBRD LCLKTRD PRCLKRD RDOFF SAOFF
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 RFLOAT CLK LME LWE MCLK METRD RST
+STCLK STCLKWR T1B me84a03_CENRD_LITE
XI60 ACUTRK RMENB RW_RBL Z0B Z2 Z1 Z0 PRM04 PRM03 PRM02 PRM01
+PRM00 PRM14 PRM13 PRM12 PRM11 PRM10 RMDEF2 RMDEF1 RMDEF0 RMEN
+RMENI1 RMENI0 RMEXT3 RMEXT2 RMEXT1 RMEXT0 RMFAST2 RMFAST1
+RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 me84a03_RMMX
XMI46 VDD LOG0 LOG1 VDD P12_LP W=6.0U L=me84a03_LD M=1
XXADRRDMUX QXARD6 QXARD5 QXARD4 QXARD3 QXARD2 QXARD1 QXARD0
+QYARD1 QYARD0 XARD6 XARD5 XARD4 XARD3 XARD2 XARD1 XARD0
+YARD1 YARD0 me84a03_ADRMUX_LITE
XXR LME LWE LWEI LWER MCLK MERDA0 MERDA1 METRD T1B WEA0 WEA1 LCLKBRD CLK LCLKTRD
+ ME SMERD SWE TEST1 WE me84a03_CTRL_LITE
XMI45 VSS LOG1 LOG0 VSS N12_LP W=6.0U L=me84a03_LD M=1
.ENDS me84a03_CENTER_SD_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CENTER_LITE                                                          *
* LAST TIME SAVED:  MAY 08 15:23:03 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CENTER_LITE ACUTRK CCOR CCRDL CCRDR CCWR DCLKBL DCLKBR LWEL LWER MCLK
+MERDA0 MERDA1 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1
+PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9
+PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1
+PBRDB0 PCBL3 PCBL2 PCBL1 PCBL0 PCBR3 PCBR2 PCBR1 PCBR0 RDOFF
+RLYA1QB RLYA1QT RMENB RW_RBL SAEBL SAOFF T1B WCLKRD1 WCLKRD0 WCLKRDB1
+WCLKRDB0 WEA0 WEA1 Z0B Z2 Z1 Z0 LOG0 LOG1 PRM04 PRM03 PRM02
+PRM01 PRM00 PRM14 PRM13 PRM12 PRM11 PRM10 SAEBRT CLK ME RCSHARE
+RMDEF2 RMDEF1 RMDEF0 RMEN RMENI1 RMENI0 RMEXT3 RMEXT2 RMEXT1
+RMEXT0 RMFAST2 RMFAST1 RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 RST SMERD
+STCLK STCLKWR SWE TEST1 WE XARD6 XARD5 XARD4 XARD3 XARD2 XARD1
+XARD0 YARD1 YARD0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO ACUTRK:O CCOR:O CCRDL:O CCRDR:O CCWR:O DCLKBL:O DCLKBR:O LWEL:O LWER:O MCLK:O
*.PININFO MERDA0:O MERDA1:O PARDB7:O PARDB6:O PARDB5:O PARDB4:O PARDB3:O
*.PININFO PARDB2:O PARDB1:O PARDB0:O PBRDB15:O PBRDB14:O PBRDB13:O PBRDB12:O
*.PININFO PBRDB11:O PBRDB10:O PBRDB9:O PBRDB8:O PBRDB7:O PBRDB6:O PBRDB5:O
*.PININFO PBRDB4:O PBRDB3:O PBRDB2:O PBRDB1:O PBRDB0:O PCBL3:O PCBL2:O
*.PININFO PCBL1:O PCBL0:O PCBR3:O PCBR2:O PCBR1:O PCBR0:O RDOFF:O RLYA1QB:O
*.PININFO RLYA1QT:O RMENB:O RW_RBL:O SAEBL:O SAOFF:O T1B:O WCLKRD1:O WCLKRD0:O
*.PININFO WCLKRDB1:O WCLKRDB0:O WEA0:O WEA1:O Z0B:O Z2:O Z1:O Z0:O LOG0:B LOG1:B
*.PININFO PRM04:B PRM03:B PRM02:B PRM01:B PRM00:B PRM14:B PRM13:B PRM12:B
*.PININFO PRM11:B PRM10:B SAEBRT:B CLK:I ME:I RCSHARE:I RMDEF2:I RMDEF1:I
*.PININFO RMDEF0:I RMEN:I RMENI1:I RMENI0:I RMEXT3:I RMEXT2:I RMEXT1:I
*.PININFO RMEXT0:I RMFAST2:I RMFAST1:I RMFAST0:I RMSLOW2:I RMSLOW1:I
*.PININFO RMSLOW0:I RST:I SMERD:I STCLK:I STCLKWR:I SWE:I TEST1:I WE:I XARD6:I
*.PININFO XARD5:I XARD4:I XARD3:I XARD2:I XARD1:I XARD0:I YARD1:I YARD0:I
XXCBUF CCRDL RCSHARE DCLKBL FLOATI YA0QB YA0QT RLYA1QB LWEI LWEL PCBL0 PCBL1
+PCBL2 PCBL3 PRCLK SAEBL SAEBRT SAOFF me84a03_CBUF_LITE
XI61 ACUTRK CCOR CCRDR CCWR CLK DCLKBR FLOATI LOG0 LOG1 LWEI LWER MCLK ME MERDA0
+MERDA1 PARDB0 PARDB1 PARDB2 PARDB3 PARDB4 PARDB5 PARDB6 PARDB7
+PBRDB0 PBRDB1 PBRDB10 PBRDB11 PBRDB12 PBRDB13 PBRDB14 PBRDB15
+PBRDB2 PBRDB3 PBRDB4 PBRDB5 PBRDB6 PBRDB7 PBRDB8 PBRDB9 PCBR0
+PCBR1 PCBR2 PCBR3 PRCLK PRM00 PRM01 PRM02 PRM03 PRM04 PRM10
+PRM11 PRM12 PRM13 PRM14 RCSHARE RDOFF YA0QB YA0QT RLYA1QB RLYA1QT
+RMDEF0 RMDEF1 RMDEF2 RMEN RMENB RMENI0 RMENI1 RMEXT0 RMEXT1
+RMEXT2 RMEXT3 RMFAST0 RMFAST1 RMFAST2 RMSLOW0 RMSLOW1 RMSLOW2
+RST RW_RBL SAEBRT SAOFF SMERD STCLK STCLKWR SWE T1B TEST1 WCLKRD0 WCLKRD1
+WCLKRDB0 WCLKRDB1 WE WEA0 WEA1 XARD0 XARD1 XARD2 XARD3 XARD4
+XARD5 XARD6 YARD0 YARD1 Z0 Z0B Z1 Z2 me84a03_CENTER_SD_LITE
.ENDS me84a03_CENTER_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X1P11CM4_LITE                                                        *
* LAST TIME SAVED:  MAY 08 15:23:11 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X1P11CM4_LITE Q3 Q2 Q1 Q0 CLK D3 D2 D1 D0 ME RM3 RM2
+ RM1 RM0 RMDEF2 RMDEF1 RMDEF0 RMEN RMFAST2 RMFAST1 RMFAST0
+RMSLOW2 RMSLOW1 RMSLOW0 RST TEST1 WE WEM3 WEM2 WEM1 WEM0 XA6
+XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD
+LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO Q3:O Q2:O Q1:O Q0:O CLK:I D3:I D2:I D1:I D0:I ME:I RM3:I
*.PININFO RM2:I RM1:I RM0:I RMDEF2:I RMDEF1:I RMDEF0:I RMEN:I RMFAST2:I
*.PININFO RMFAST1:I RMFAST0:I RMSLOW2:I RMSLOW1:I RMSLOW0:I RST:I TEST1:I WE:I
*.PININFO WEM3:I WEM2:I WEM1:I WEM0:I XA6:I XA5:I XA4:I XA3:I XA2:I
*.PININFO XA1:I XA0:I YA1:I YA0:I
XXWAR4R BBR7 BBR6 BBR5 BBR4 BBR3 BBR2 BBR1 BBR0 BTR7 BTR6
+BTR5 BTR4 BTR3 BTR2 BTR1 BTR0 LOG0 LOG1 RWLR RWLR me84a03_WAR4_RT
XXARRR BBR7 BBR6 BBR5 BBR4 BBR3 BBR2 BBR1 BBR0 BTR7 BTR6
+BTR5 BTR4 BTR3 BTR2 BTR1 BTR0 LOG0 WLR7 WLR6 WLR5 WLR4
+WLR3 WLR2 WLR1 WLR0 me84a03_AR4_RT
XI19 LOG0 LOG1 me84a03_CAP_RT
XXHSLREF LOG0 RBLRD RBLWR WLR7 WLR6 WLR5 WLR4 WLR3 WLR2 WLR1
+WLR0 me84a03_HSLREF
XIX8DEC WLL7 WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 WLR7 WLR6
+WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 ACUTRK VDD VDD WRREF Z2 Z1 Z0
+PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1 PARDB0
+PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9 PBRDB8
+PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1 PBRDB0
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 me84a03_X8DEC
XXWAR4L BBL7 BBL6 BBL5 BBL4 BBL3 BBL2 BBL1 BBL0 BTL7 BTL6
+BTL5 BTL4 BTL3 BTL2 BTL1 BTL0 LOG0 LOG1 RWLL RWLL me84a03_WAR4_LT
XXARRL BBL7 BBL6 BBL5 BBL4 BBL3 BBL2 BBL1 BBL0 BTL7 BTL6
+BTL5 BTL4 BTL3 BTL2 BTL1 BTL0 LOG0 WLL7 WLL6 WLL5 WLL4
+WLL3 WLL2 WLL1 WLL0 me84a03_AR4_LT
XI20 LOG0 LOG1 me84a03_CAP_LT
XXRW RWLL RWLR WRREF LOG0 LOG1 RBLRD RBLWR VDD VDD WCLKRD0 WCLKRDB0 ACUTRK
+RWLR Z2 Z1 Z0 me84a03_RW
XXRIO CCOR CCRD CCWR DCLKBR LOG0 LOG1 LWER MCLK PRCHRDBR0 PRCHRDBR1
+PRCHRDBR2 PRCHRDBR3 RBLRD RBLWR NET98 NET216 SAEB SAEBRT SAOFF STCLK
+STCLKWR T1B WRREF me84a03_RIO_BL_LITE
XXIO00 BBL0 BBL1 BBL2 BBL3 BTL0 BTL1 BTL2 BTL3 CCRDL D0 DCLKBL
+LOG0 LOG1 LWEL PRCHRDBL0 PRCHRDBL1 PRCHRDBL2 PRCHRDBL3 Q0 SAEBL
+WEM0 NET317 NET102 NET317 me84a03_IOCM4_LITE
XXIO01 BBL4 BBL5 BBL6 BBL7 BTL4 BTL5 BTL6 BTL7 CCRDL D1 DCLKBL
+LOG0 LOG1 LWEL PRCHRDBL0 PRCHRDBL1 PRCHRDBL2 PRCHRDBL3 Q1 SAEBL
+WEM1 NET314 NET101 NET314 me84a03_IOCM4_LITE
XXIO04 BBR4 BBR5 BBR6 BBR7 BTR4 BTR5 BTR6 BTR7 CCRD D3 DCLKBR
+LOG0 LOG1 LWER PRCHRDBR0 PRCHRDBR1 PRCHRDBR2 PRCHRDBR3 Q3 SAEB WEM3
+NET309 NET96 NET309 me84a03_IOCM4_LITE
XXIO03 BBR0 BBR1 BBR2 BBR3 BTR0 BTR1 BTR2 BTR3 CCRD D2 DCLKBR
+LOG0 LOG1 LWER PRCHRDBR0 PRCHRDBR1 PRCHRDBR2 PRCHRDBR3 Q2 SAEB WEM2
+NET320 NET97 NET320 me84a03_IOCM4_LITE
XXCENTER ACUTRK CCOR CCRDL CCRD CCWR DCLKBL DCLKBR LWEL LWER MCLK NET238 NET239
+PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1 PARDB0
+PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9 PBRDB8
+PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1 PBRDB0
+PRCHRDBL3 PRCHRDBL2 PRCHRDBL1 PRCHRDBL0 PRCHRDBR3 PRCHRDBR2
+PRCHRDBR1 PRCHRDBR0 NET100 NET235 NET233 RMENB NET216 SAEBL SAOFF T1B
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 NET99 NET236 Z0B Z2 Z1 Z0 LOG0
+LOG1 RM0N RM0N VDD RM0N1 RM0N RM1N RM1P1 RM1N RM1N VSS SAEBRT CLK ME NET233
+RMDEF2 RMDEF1 RMDEF0 RMEN RMENB RMEN RM3 RM2 RM1 RM0 RMFAST2
+RMFAST1 RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 RST NET239 STCLK STCLKWR
+NET236 TEST1 WE XA6 XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0
+me84a03_CENTER_LITE
XXWARREF LOG0 LOG1 RBLRD RBLWR RWLR RWLR me84a03_WARREF
.ENDS me84a03_X1P11CM4_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X1P11CM2_LITE                                                        *
* LAST TIME SAVED:  MAY 08 15:22:55 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X1P11CM2_LITE Q3 Q2 Q1 Q0 CLK D3 D2 D1 D0 ME RM3 RM2
+ RM1 RM0 RMDEF2 RMDEF1 RMDEF0 RMEN RMFAST2 RMFAST1 RMFAST0
+RMSLOW2 RMSLOW1 RMSLOW0 RST TEST1 WE XA6 XA5 XA4 XA3 XA2 XA1
+XA0 YA1 YA0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO Q3:O Q2:O Q1:O Q0:O CLK:I D3:I D2:I D1:I D0:I ME:I RM3:I
*.PININFO RM2:I RM1:I RM0:I RMDEF2:I RMDEF1:I RMDEF0:I RMEN:I RMFAST2:I
*.PININFO RMFAST1:I RMFAST0:I RMSLOW2:I RMSLOW1:I RMSLOW0:I RST:I TEST1:I WE:I
*.PININFO XA6:I XA5:I XA4:I XA3:I XA2:I XA1:I XA0:I YA1:I YA0:I
XXHSLREF LOG0 RBLRD RBLWR WLR7 WLR6 WLR5 WLR4 WLR3 WLR2 WLR1
+WLR0 me84a03_HSLREF
XXWARREF LOG0 LOG1 RBLRD RBLWR RWLR RWLR me84a03_WARREF
XIX8DEC WLL7 WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 WLR7 WLR6
+WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 ACUTRK VDD VDD WRREF Z2 Z1 Z0
+PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1 PARDB0
+PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9 PBRDB8
+PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1 PBRDB0
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 me84a03_X8DEC
XXRW RWLL RWLR WRREF LOG0 LOG1 RBLRD RBLWR VDD VDD WCLKRD0 WCLKRDB0 ACUTRK
+RWLR Z2 Z1 Z0 me84a03_RW_LC
XXWAR2R BBR3 BBR2 BBR1 BBR0 BTR3 BTR2 BTR1 BTR0 LOG0 LOG1 RWLR
+RWLR me84a03_WAR2_RT
XXARRR BBR3 BBR2 BBR1 BBR0 BTR3 BTR2 BTR1 BTR0 LOG0 WLR7
+WLR6 WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 me84a03_AR2_RT
XXARRL BBL3 BBL2 BBL1 BBL0 BTL3 BTL2 BTL1 BTL0 LOG0 WLL7
+WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 me84a03_AR2_LT
XXWAR2L BBL3 BBL2 BBL1 BBL0 BTL3 BTL2 BTL1 BTL0 LOG0 LOG1 RWLL
+RWLL me84a03_WAR2_LT
XXRIO CCOR CCRD CCWR DCLKBR LOG0 LOG1 LWER MCLK PRCHRDBR0 PRCHRDBR1
+PRCHRDBR2 PRCHRDBR3 RBLRD RBLWR NET90 NET179 SAEB SAEBRT SAOFF STCLK
+STCLKWR T1B WRREF me84a03_RIO_BL_LITE
XXIO00 BBL0 BBL1 BTL0 BTL1 CCRDL D0 DCLKBL LOG0 LOG1 LWEL LWEL
+PRCHRDBL2 PRCHRDBL3 Q0 SAEBL me84a03_IOCM2_LITE
XXIO01 BBL2 BBL3 BTL2 BTL3 CCRDL D1 DCLKBL LOG0 LOG1 LWEL LWEL
+PRCHRDBL0 PRCHRDBL1 Q1 SAEBL me84a03_IOCM2_LITE
XXIO03 BBR0 BBR1 BTR0 BTR1 CCRD D2 DCLKBR LOG0 LOG1 LWER LWER
+PRCHRDBR0 PRCHRDBR1 Q2 SAEB me84a03_IOCM2_LITE
XXIO04 BBR2 BBR3 BTR2 BTR3 CCRD D3 DCLKBR LOG0 LOG1 LWER LWER
+PRCHRDBR2 PRCHRDBR3 Q3 SAEB me84a03_IOCM2_LITE
XXCENTER ACUTRK CCOR CCRDL CCRD CCWR DCLKBL DCLKBR LWEL LWER MCLK NET94 NET215
+PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1 PARDB0
+PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9 PBRDB8
+PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1 PBRDB0
+PRCHRDBL3 PRCHRDBL2 PRCHRDBL1 PRCHRDBL0 PRCHRDBR3 PRCHRDBR2
+PRCHRDBR1 PRCHRDBR0 NET93 NET220 NET92 RMENB NET179 SAEBL SAOFF T1B
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 NET91 NET217 Z0B Z2 Z1 Z0 LOG0
+LOG1 RM0N RM0N VDD RM0N1 RM0N RM1N RM1P1 RM1N RM1N VSS SAEBRT CLK ME NET220
+RMDEF2 RMDEF1 RMDEF0 RMEN RMENB RMEN RM3 RM2 RM1 RM0 RMFAST2
+RMFAST1 RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 RST NET215 STCLK STCLKWR
+NET217 TEST1 WE XA6 XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0
+me84a03_CENTER_LITE
XI19 LOG0 LOG1 me84a03_CAP_RT
XI20 LOG0 LOG1 me84a03_CAP_LT
.ENDS me84a03_X1P11CM2_LITE

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CBUF                                                                 *
* LAST TIME SAVED:  MAY 08 15:23:07 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CBUF AWT BCBL BCTL BISTE CCRDL CSHARE DCLKBL FLOATI LA0QB LA0QT LA1QB
+LWEI LWEL PRCHBL0 PRCHBL1 PRCHBL2 PRCHBL3 PRCLK SAEBL SAEBRT SAOFF
+SWBAWTBL SWBAWTL
*.PININFO AWT:I BCBL:O BCTL:O BISTE:I CCRDL:O CSHARE:I DCLKBL:O FLOATI:I LA0QB:I LA0QT:I
*.PININFO LA1QB:I LWEI:I LWEL:O PRCHBL0:O PRCHBL1:O PRCHBL2:O PRCHBL3:O PRCLK:I
*.PININFO SAEBL:O SAEBRT:I SAOFF:I SWBAWTBL:O SWBAWTL:O
XI131 PRCHBL3 LA0QT CSHARE PRCLK me84a03_DEC2TO1
XI130 PRCHBL2 LA0QB CSHARE PRCLK me84a03_DEC2TO1
XI129 PRCHBL1 LA0QT LA1QB PRCLK me84a03_DEC2TO1
XI128 PRCHBL0 LA0QB LA1QB PRCLK me84a03_DEC2TO1
XI48 SWBAWTL SWBAWTBL me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.5U WP=3.0U
XI47 SWBAWTBL AWT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.5U WP=3.0U
XI54 LWEL LWEI me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=3.0U WP=6.0U
XI20 BCBL BISTE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.5U WP=3.0U
XI21 BCTL BCBL me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.5U WP=3.0U
XI0 CCRDL SAOFF me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=3.0U WP=6.0U
XI55 DCLKBL FLOATI me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=3.0U WP=6.0U
XI23 SAEBL SAEBRT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=8.8U WP=5.2U
.ENDS me84a03_CBUF

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CENRD                                                                *
* LAST TIME SAVED:  MAY 08 15:22:58 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CENRD CCOR CCRDR CCWR DCLKBR FLOATI LCLKB LCLKT PRCLKRD RDOFF SAOFF
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 FLOAT BCB BCT CLK LME LWE MCLK MET
+RST STCLK STCLKWR T1B TCLK LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO CCOR:O CCRDR:O CCWR:O DCLKBR:O FLOATI:O LCLKB:O LCLKT:O PRCLKRD:O RDOFF:O
*.PININFO SAOFF:O WCLKRD1:O WCLKRD0:O WCLKRDB1:O WCLKRDB0:O FLOAT:B BCB:I BCT:I
*.PININFO CLK:I LME:I LWE:I MCLK:I MET:I RST:I STCLK:I STCLKWR:I T1B:I TCLK:I
XI60 CCWR CCWRB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI19 LCLKB LCLKT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.5U WP=4.5U
XI32 LWEB LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.3U
XI8 NET098 LMELCLKB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.7U WP=1.4U
XI45 FBR FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.3U
XI29 LMECT LMECB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI44 FBW FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI34 CCOR CCORB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI37 FLOATI FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=2.0U WP=4.0U
XI35 DCLKBR FLOATI me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=3.0U WP=6.0U
XI50 LMECB FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.15U
XI46 RDOFF NET098 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=4U WP=4U
XI48 PRCLKRD FLOAT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=4U WP=5U
XXWC WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 WCTRD me84a03_WCLKBUF
XI15 CCRDR SAOFF CCORB me84a03_CCBUF
XI915 FLOAT WCTRD BCB BCT CLK LME MCLK RST STCLK STCLKWR TCLK T1B me84a03_CLOCK
XI24 LMELCLKB LMECT LMECB MET me84a03_L0B
XI61 CCWRB FBW LWE T1B me84a03_ND3 WN1=0.5U WN2=0.5U WN3=0.5U WP1=0.5U WP2=0.5U WP3=0.5U
XI43 CCORB FBR LWEB me84a03_ND2 WN1=1.0U WN2=1.0U WP1=1.0U WP2=1.0U
XI49 LCLKT FLOAT MET me84a03_ND2 WN1=3.0U WN2=3.0U WP1=3.0U WP2=1.0U
.ENDS me84a03_CENRD

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CTRL                                                                 *
* LAST TIME SAVED:  MAY 08 15:22:59 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CTRL BCBR BCTR LME LWE LWEI LWER MCLK MERDA0 MERDA1 METRD QM SWBAWTBR
+SWBAWTR T1B WEA0 WEA1 ADXOR AWT BISTE CB CLK CT ME SMERD SWE TCLK TEST1 TME TWE
+ WE LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BCBR:O BCTR:O LME:O LWE:O LWEI:O LWER:O MCLK:O MERDA0:O MERDA1:O METRD:O QM:O
*.PININFO SWBAWTBR:O SWBAWTR:O T1B:O WEA0:O WEA1:O ADXOR:I AWT:I BISTE:I CB:I CLK:I CT:I
*.PININFO ME:I SMERD:I SWE:I TCLK:I TEST1:I TME:I TWE:I WE:I
XXLWE LWE CB CT METWRB me84a03_L0B
XI43 METRDB SMERD me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.5U WP=1.0U
XI124 BCTR BCBR me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.5U WP=3.0U
XI125 BCBR BISTE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.5U WP=3.0U
XI57 LWEI LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.8U WP=1.5U
XI19 MCLKT MCLKB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.35U WP=0.7U
XI149 METRD METRDB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.0U WP=2.0U
XI50 SWBAWTR SWBAWTBR me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.5U WP=3.0U
XI26 T1B TEST1 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.2U WP=0.4U
XI49 SWBAWTBR AWT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=1.5U WP=3.0U
XI16 QM NET0161 me84a03_INV WN=2.4U WP=1.2U
XI54 LWER LWEI me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=3.0U WP=6.0U
XXLME LME MCLKB MCLKT METRDB me84a03_L1B
XI7 NET0120 NET0123 ADXOR me84a03_XOR2B LN2=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
XI14 NET0123 MERDA1 WEA1 me84a03_XOR2B LN2=me84a03_LD LP2=me84a03_LD WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
XXBMERD MERDA0 MERDA1 ME BCBR BCTR TME me84a03_BEMX_CTRL
XXBWE WEA0 WEA1 WE BCBR BCTR TWE me84a03_BEMX_CTRL
XXBMC MCLKB MCLK CLK BCBR BCTR TCLK me84a03_BEMX_CTRL
DI44 VSS AWT NDIO12_LP AREA=ARD PJ=PRD
DI0 VSS TEST1 NDIO12_LP AREA=ARD PJ=PRD
DI37 VSS BISTE NDIO12_LP AREA=ARD PJ=PRD
XI42 NET0161 NET0120 AWT me84a03_ND2 WN1=0.8U WN2=0.8U WP1=0.4U WP2=0.4U
XI58 METWRB SWE SMERD me84a03_ND2 WN1=0.7U WN2=0.7U WP1=0.7U WP2=0.7U
.ENDS me84a03_CTRL

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CENTER_SD                                                            *
* LAST TIME SAVED:  MAY 08 15:23:08 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CENTER_SD ACUTRK AWT BCBR BCTR BISTE CCOR CCRDR CCWR CLK DCLKBR FLOATI
+LOG0 LOG1 LWEI LWER MCLK ME MERDA0 MERDA1 PARDB0 PARDB1 PARDB2 PARDB3
+PARDB4 PARDB5 PARDB6 PARDB7 PBRDB0 PBRDB1 PBRDB10 PBRDB11
+PBRDB12 PBRDB13 PBRDB14 PBRDB15 PBRDB2 PBRDB3 PBRDB4 PBRDB5
+PBRDB6 PBRDB7 PBRDB8 PBRDB9 PCBR0 PCBR1 PCBR2 PCBR3 PRCLKRD
+PRM00 PRM01 PRM02 PRM03 PRM04 PRM10 PRM11 PRM12 PRM13 PRM14
+ QM RCSHARE RDOFF RLYA0QB RLYA0QT RLYA1QB RLYA1QT RMDEF0 RMDEF1 RMDEF2
+RMEN RMENB RMENI0 RMENI1 RMEXT0 RMEXT1 RMEXT2 RMEXT3 RMFAST0
+RMFAST1 RMFAST2 RMSLOW0 RMSLOW1 RMSLOW2 RST RW_RBL SAEBRT SAOFF SMERD
+ STCLK STCLKWR SWBAWTBR SWBAWTR SWE T1B TCLK TEST1 TME TWE TXARD0 TXARD1
+TXARD2 TXARD3 TXARD4 TXARD5 TXARD6 TYARD0 TYARD1 WCLKRD0
+WCLKRD1 WCLKRDB0 WCLKRDB1 WE WEA0 WEA1 XARD0 XARD1 XARD2 XARD3
+XARD4 XARD5 XARD6 YARD0 YARD1 Z0 Z0B Z1 Z2 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND
+ LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO ACUTRK:O AWT:I BCBR:O BCTR:O BISTE:I CCOR:O CCRDR:O CCWR:O CLK:I DCLKBR:O
*.PININFO FLOATI:O LOG0:B LOG1:B LWEI:O LWER:O MCLK:O ME:I MERDA0:O MERDA1:O PARDB0:O
*.PININFO PARDB1:O PARDB2:O PARDB3:O PARDB4:O PARDB5:O PARDB6:O PARDB7:O
*.PININFO PBRDB0:O PBRDB1:O PBRDB10:O PBRDB11:O PBRDB12:O PBRDB13:O
*.PININFO PBRDB14:O PBRDB15:O PBRDB2:O PBRDB3:O PBRDB4:O PBRDB5:O PBRDB6:O
*.PININFO PBRDB7:O PBRDB8:O PBRDB9:O PCBR0:O PCBR1:O PCBR2:O PCBR3:O
*.PININFO PRCLKRD:O PRM00:B PRM01:B PRM02:B PRM03:B PRM04:B PRM10:B PRM11:B
*.PININFO PRM12:B PRM13:B PRM14:B QM:O RCSHARE:I RDOFF:O RLYA0QB:O RLYA0QT:O
*.PININFO RLYA1QB:O RLYA1QT:O RMDEF0:I RMDEF1:I RMDEF2:I RMEN:I RMENB:O RMENI0:I
*.PININFO RMENI1:I RMEXT0:I RMEXT1:I RMEXT2:I RMEXT3:I RMFAST0:I RMFAST1:I
*.PININFO RMFAST2:I RMSLOW0:I RMSLOW1:I RMSLOW2:I RST:I RW_RBL:O SAEBRT:B SAOFF:O
*.PININFO SMERD:I STCLK:I STCLKWR:I SWBAWTBR:O SWBAWTR:O SWE:I T1B:O TCLK:I TEST1:I TME:I
*.PININFO TWE:I TXARD0:I TXARD1:I TXARD2:I TXARD3:I TXARD4:I TXARD5:I
*.PININFO TXARD6:I TYARD0:I TYARD1:I WCLKRD0:O WCLKRD1:O WCLKRDB0:O
*.PININFO WCLKRDB1:O WE:I WEA0:O WEA1:O XARD0:I XARD1:I XARD2:I XARD3:I
*.PININFO XARD4:I XARD5:I XARD6:I YARD0:I YARD1:I Z0:O Z0B:O Z1:O Z2:O
XXCENRD CCOR CCRDR CCWR DCLKBR FLOATI LCLKBRD LCLKTRD PRCLKRD RDOFF SAOFF
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 RFLOAT BCBR BCTR CLK LME LWE MCLK
+METRD RST STCLK STCLKWR T1B TCLK me84a03_CENRD
XI37 LOG0 me84a03_LOG
XI60 ACUTRK RMENB RW_RBL Z0B Z2 Z1 Z0 PRM04 PRM03 PRM02 PRM01
+PRM00 PRM14 PRM13 PRM12 PRM11 PRM10 RMDEF2 RMDEF1 RMDEF0 RMEN
+RMENI1 RMENI0 RMEXT3 RMEXT2 RMEXT1 RMEXT0 RMFAST2 RMFAST1
+RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 me84a03_RMMX
XXADRRDMUX ADXOR QXARD6 QXARD5 QXARD4 QXARD3 QXARD2 QXARD1 QXARD0
+QYARD1 QYARD0 BCBR BCTR TXARD6 TXARD5 TXARD4 TXARD3 TXARD2
+TXARD1 TXARD0 TYARD1 TYARD0 XARD6 XARD5 XARD4 XARD3 XARD2
+XARD1 XARD0 YARD1 YARD0 me84a03_ADRMUX
XMI46 VDD LOG0 LOG1 VDD P12_LP W=6.0U L=me84a03_LD M=1
XXR BCBR BCTR LME LWE LWEI LWER MCLK MERDA0 MERDA1 METRD QM SWBAWTBR SWBAWTR T1B
+ WEA0 WEA1 ADXOR AWT BISTE LCLKBRD CLK LCLKTRD ME SMERD SWE TCLK TEST1 TME TWE
+WE me84a03_CTRL
XXADRD RLYA0QB RLYA0QT RLYA1QB RLYA1QT PARDB7 PARDB6 PARDB5 PARDB4
+PARDB3 PARDB2 PARDB1 PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12
+PBRDB11 PBRDB10 PBRDB9 PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4
+PBRDB3 PBRDB2 PBRDB1 PBRDB0 PCBR3 PCBR2 PCBR1 PCBR0 RCSHARE
+LCLKBRD LCLKTRD PRCLKRD QXARD6 QXARD5 QXARD4 QXARD3 QXARD2 QXARD1
+QXARD0 QYARD1 QYARD0 me84a03_ADRGEN
XMI45 VSS LOG1 LOG0 VSS N12_LP W=6.0U L=me84a03_LD M=1
.ENDS me84a03_CENTER_SD

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_CENTER                                                               *
* LAST TIME SAVED:  MAY 08 15:22:52 2014                                      *
*******************************************************************************
.SUBCKT me84a03_CENTER ACUTRK BCBL BCBR BCTL BCTR CCOR CCRDL CCRDR CCWR DCLKBL DCLKBR
+LWEL LWER MCLK MERDA0 MERDA1 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3
+PARDB2 PARDB1 PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11
+PBRDB10 PBRDB9 PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3
+PBRDB2 PBRDB1 PBRDB0 PCBL3 PCBL2 PCBL1 PCBL0 PCBR3 PCBR2
+PCBR1 PCBR0 QM RDOFF RLYA1QB RLYA1QT RMENB RW_RBL SAEBL SAOFF SWBAWTBL
+SWBAWTBR SWBAWTL SWBAWTR T1B WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 WEA0
+WEA1 Z0B Z2 Z1 Z0 LOG0 LOG1 PRM04 PRM03 PRM02 PRM01 PRM00
+PRM14 PRM13 PRM12 PRM11 PRM10 SAEBRT AWT BISTE CLK ME RCSHARE
+RMDEF2 RMDEF1 RMDEF0 RMEN RMENI1 RMENI0 RMEXT3 RMEXT2 RMEXT1
+RMEXT0 RMFAST2 RMFAST1 RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 RST SMERD
+STCLK STCLKWR SWE TCLK TEST1 TME TWE TXARD6 TXARD5 TXARD4 TXARD3
+TXARD2 TXARD1 TXARD0 TYARD1 TYARD0 WE XARD6 XARD5 XARD4 XARD3
+ XARD2 XARD1 XARD0 YARD1 YARD0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD
+LP2=me84a03_LPD
*.PININFO ACUTRK:O BCBL:O BCBR:O BCTL:O BCTR:O CCOR:O CCRDL:O CCRDR:O CCWR:O DCLKBL:O
*.PININFO DCLKBR:O LWEL:O LWER:O MCLK:O MERDA0:O MERDA1:O PARDB7:O PARDB6:O PARDB5:O
*.PININFO PARDB4:O PARDB3:O PARDB2:O PARDB1:O PARDB0:O PBRDB15:O PBRDB14:O
*.PININFO PBRDB13:O PBRDB12:O PBRDB11:O PBRDB10:O PBRDB9:O PBRDB8:O PBRDB7:O
*.PININFO PBRDB6:O PBRDB5:O PBRDB4:O PBRDB3:O PBRDB2:O PBRDB1:O PBRDB0:O
*.PININFO PCBL3:O PCBL2:O PCBL1:O PCBL0:O PCBR3:O PCBR2:O PCBR1:O PCBR0:O
*.PININFO QM:O RDOFF:O RLYA1QB:O RLYA1QT:O RMENB:O RW_RBL:O SAEBL:O SAOFF:O SWBAWTBL:O
*.PININFO SWBAWTBR:O SWBAWTL:O SWBAWTR:O T1B:O WCLKRD1:O WCLKRD0:O WCLKRDB1:O
*.PININFO WCLKRDB0:O WEA0:O WEA1:O Z0B:O Z2:O Z1:O Z0:O LOG0:B LOG1:B PRM04:B
*.PININFO PRM03:B PRM02:B PRM01:B PRM00:B PRM14:B PRM13:B PRM12:B PRM11:B
*.PININFO PRM10:B SAEBRT:B AWT:I BISTE:I CLK:I ME:I RCSHARE:I RMDEF2:I RMDEF1:I
*.PININFO RMDEF0:I RMEN:I RMENI1:I RMENI0:I RMEXT3:I RMEXT2:I RMEXT1:I
*.PININFO RMEXT0:I RMFAST2:I RMFAST1:I RMFAST0:I RMSLOW2:I RMSLOW1:I
*.PININFO RMSLOW0:I RST:I SMERD:I STCLK:I STCLKWR:I SWE:I TCLK:I TEST1:I TME:I TWE:I
*.PININFO TXARD6:I TXARD5:I TXARD4:I TXARD3:I TXARD2:I TXARD1:I TXARD0:I
*.PININFO TYARD1:I TYARD0:I WE:I XARD6:I XARD5:I XARD4:I XARD3:I XARD2:I
*.PININFO XARD1:I XARD0:I YARD1:I YARD0:I
XXCBUF AWT BCBL BCTL BISTE CCRDL RCSHARE DCLKBL FLOATI YA0QB YA0QT RLYA1QB LWEI
+LWEL PCBL0 PCBL1 PCBL2 PCBL3 PRCLK SAEBL SAEBRT SAOFF SWBAWTBL SWBAWTL
+me84a03_CBUF
XXC ACUTRK AWT BCBR BCTR BISTE CCOR CCRDR CCWR CLK DCLKBR FLOATI LOG0 LOG1 LWEI
+LWER MCLK ME MERDA0 MERDA1 PARDB0 PARDB1 PARDB2 PARDB3 PARDB4
+PARDB5 PARDB6 PARDB7 PBRDB0 PBRDB1 PBRDB10 PBRDB11 PBRDB12
+PBRDB13 PBRDB14 PBRDB15 PBRDB2 PBRDB3 PBRDB4 PBRDB5 PBRDB6
+PBRDB7 PBRDB8 PBRDB9 PCBR0 PCBR1 PCBR2 PCBR3 PRCLK PRM00
+PRM01 PRM02 PRM03 PRM04 PRM10 PRM11 PRM12 PRM13 PRM14 QM
+RCSHARE RDOFF YA0QB YA0QT RLYA1QB RLYA1QT RMDEF0 RMDEF1 RMDEF2 RMEN RMENB
+RMENI0 RMENI1 RMEXT0 RMEXT1 RMEXT2 RMEXT3 RMFAST0 RMFAST1
+RMFAST2 RMSLOW0 RMSLOW1 RMSLOW2 RST RW_RBL SAEBRT SAOFF SMERD STCLK
+STCLKWR SWBAWTBR SWBAWTR SWE T1B TCLK TEST1 TME TWE TXARD0 TXARD1 TXARD2
+TXARD3 TXARD4 TXARD5 TXARD6 TYARD0 TYARD1 WCLKRD0 WCLKRD1
+WCLKRDB0 WCLKRDB1 WE WEA0 WEA1 XARD0 XARD1 XARD2 XARD3 XARD4
+XARD5 XARD6 YARD0 YARD1 Z0 Z0B Z1 Z2 me84a03_CENTER_SD
.ENDS me84a03_CENTER

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_RIO_LOGIC                                                            *
* LAST TIME SAVED:  MAY 08 15:23:12 2014                                      *
*******************************************************************************
.SUBCKT me84a03_RIO_LOGIC SAEBR SAEBRT STCLK STCLKWR BCB BCT CCRD DCLKB LOG0 LOG1 LWE
+PCB3 PCB2 PCB1 PCB0 SWBAWT SWBAWTB CCOR CCWR MCLK SAOFF T1B Z0B LN=me84a03_LND
+LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO SAEBR:O SAEBRT:O STCLK:O STCLKWR:O BCB:B BCT:B CCRD:B DCLKB:B LOG0:B LOG1:B
*.PININFO LWE:B PCB3:B PCB2:B PCB1:B PCB0:B SWBAWT:B SWBAWTB:B CCOR:I CCWR:I
*.PININFO MCLK:I SAOFF:I T1B:I Z0B:I
XI22 SAEBR SAEBRT me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=6U WP=6U
XI46 CCORW NET087 me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.3U WP=0.6U
XI56 T1T T1B me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.5U WP=1.0U
XI0 SAEBRT SAOFF STCLKMUX me84a03_NR2 WN1=1.6U WN2=1.6U WP1=10U WP2=10U
XI45 NET087 CCWR CCOR me84a03_NR2 WN1=0.3U WN2=0.3U WP1=0.6U WP2=0.6U
XI68 NET86 T1T RREF me84a03_NR2 WN1=1.2U WN2=1.2U WP1=2.8U WP2=2.8U
XI3 RREF CCORW Z0B me84a03_CC_LOOP2
XI28 STCLKMUX STCLK MCLK T1T me84a03_IMUX2ST
XI61 STCLK NET86 CCOR me84a03_ND2 WN1=4.2U WN2=4.2U WP1=2.1U WP2=2.1U
XI47 STCLKWR NET86 CCWR me84a03_ND2 WN1=3.5U WN2=3.5U WP1=1.8U WP2=1.8U
.ENDS me84a03_RIO_LOGIC

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X1P11CM2                                                             *
* LAST TIME SAVED:  MAY 08 15:22:54 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X1P11CM2 Q3 Q2 Q1 Q0 QM AWT BISTE CLK D3 D2 D1 D0 ME
+RM3 RM2 RM1 RM0 RMDEF2 RMDEF1 RMDEF0 RMEN RMFAST2 RMFAST1
+RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 RST TCLK TD3 TD2 TD1 TD0 TEST1
+TME TWE TXA6 TXA5 TXA4 TXA3 TXA2 TXA1 TXA0 TYA1 TYA0 WE XA6
+ XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD
+LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO Q3:O Q2:O Q1:O Q0:O QM:O AWT:I BISTE:I CLK:I D3:I D2:I D1:I D0:I
*.PININFO ME:I RM3:I RM2:I RM1:I RM0:I RMDEF2:I RMDEF1:I RMDEF0:I RMEN:I
*.PININFO RMFAST2:I RMFAST1:I RMFAST0:I RMSLOW2:I RMSLOW1:I RMSLOW0:I RST:I
*.PININFO TCLK:I TD3:I TD2:I TD1:I TD0:I TEST1:I TME:I TWE:I TXA6:I TXA5:I
*.PININFO TXA4:I TXA3:I TXA2:I TXA1:I TXA0:I TYA1:I TYA0:I WE:I XA6:I
*.PININFO XA5:I XA4:I XA3:I XA2:I XA1:I XA0:I YA1:I YA0:I
XXCENTER ACUTRK BCBL BCBR BCTL BCTR CCOR CCRDL CCRD CCWR DCLKBL DCLKBR LWEL LWER
+ MCLK NET103 NET225 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2
+PARDB1 PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10
+PBRDB9 PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2
+PBRDB1 PBRDB0 PRCHRDBL3 PRCHRDBL2 PRCHRDBL1 PRCHRDBL0 PRCHRDBR3
+PRCHRDBR2 PRCHRDBR1 PRCHRDBR0 QM NET102 NET230 NET101 RMENB NET174 SAEBL
+SAOFF SWBAWTBL SWBAWTBR SWBAWTL SWBAWTR T1B WCLKRD1 WCLKRD0 WCLKRDB1
+WCLKRDB0 NET100 NET227 Z0B Z2 Z1 Z0 LOG0 LOG1 RM0N RM0N VDD RM0N1 RM0N
+RM1N RM1P1 RM1N RM1N VSS SAEBRT AWT BISTE CLK ME NET230 RMDEF2 RMDEF1
+RMDEF0 RMEN RMENB RMEN RM3 RM2 RM1 RM0 RMFAST2 RMFAST1 RMFAST0
+RMSLOW2 RMSLOW1 RMSLOW0 RST NET225 STCLK STCLKWR NET227 TCLK TEST1 TME
+TWE TXA6 TXA5 TXA4 TXA3 TXA2 TXA1 TXA0 TYA1 TYA0 WE XA6
+XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0 me84a03_CENTER
XXARRR BBR3 BBR2 BBR1 BBR0 BTR3 BTR2 BTR1 BTR0 LOG0 WLR7
+WLR6 WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 me84a03_AR2_RT
XXIO00 BBL0 BBL1 BCBL BCTL BTL0 BTL1 CCRDL D0 DCLKBL LOG0 LOG1 LWEL
+LWEL PRCHRDBL2 PRCHRDBL3 Q0 SAEBL SWBAWTL SWBAWTBL TD0 me84a03_IOCM2
XXIO01 BBL2 BBL3 BCBL BCTL BTL2 BTL3 CCRDL D1 DCLKBL LOG0 LOG1 LWEL
+LWEL PRCHRDBL0 PRCHRDBL1 Q1 SAEBL SWBAWTL SWBAWTBL TD1 me84a03_IOCM2
XXIO03 BBR0 BBR1 BCBR BCTR BTR0 BTR1 CCRD D2 DCLKBR LOG0 LOG1 LWER
+LWER PRCHRDBR0 PRCHRDBR1 Q2 SAEB SWBAWTR SWBAWTBR TD2 me84a03_IOCM2
XXIO04 BBR2 BBR3 BCBR BCTR BTR2 BTR3 CCRD D3 DCLKBR LOG0 LOG1 LWER
+LWER PRCHRDBR2 PRCHRDBR3 Q3 SAEB SWBAWTR SWBAWTBR TD3 me84a03_IOCM2
XXARRL BBL3 BBL2 BBL1 BBL0 BTL3 BTL2 BTL1 BTL0 LOG0 WLL7
+WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 me84a03_AR2_LT
XXRIO SAEB SAEBRT STCLK STCLKWR BCBR BCTR CCRD DCLKBR LOG0 LOG1 LWER PRCHRDBR3
+ PRCHRDBR2 PRCHRDBR1 PRCHRDBR0 SWBAWTR SWBAWTBR CCOR CCWR MCLK SAOFF T1B
+Z0B me84a03_RIO_LOGIC
XI19 LOG0 LOG1 me84a03_CAP_RT
XI20 LOG0 LOG1 me84a03_CAP_LT
XXHSLREF LOG0 VSS VSS WLR7 WLR6 WLR5 WLR4 WLR3 WLR2 WLR1 WLR0
+me84a03_HSLREF
XIX8DEC WLL7 WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 WLR7 WLR6
+WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 ACUTRK VDD VDD VSS Z2 Z1 Z0
+PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1 PARDB0
+PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9 PBRDB8
+PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1 PBRDB0
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 me84a03_X8DEC
.ENDS me84a03_X1P11CM2

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_IOCM4                                                                *
* LAST TIME SAVED:  MAY 08 15:23:07 2014                                      *
*******************************************************************************
.SUBCKT me84a03_IOCM4 BB0 BB1 BB2 BB3 BCB BCT BT0 BT1 BT2 BT3 CCRD DA
+DCLKB LOG0 LOG1 LWE PCB0 PCB1 PCB2 PCB3 Q SAEB SWBAWT SWBAWTB TDA TWEMA
+ WEMA WEMA_AH WEMA_AL WEMA_IN LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO BB0:B BB1:B BB2:B BB3:B BCB:I BCT:I BT0:B BT1:B BT2:B BT3:B
*.PININFO CCRD:I DA:I DCLKB:I LOG0:B LOG1:B LWE:I PCB0:B PCB1:B PCB2:B PCB3:B Q:O
*.PININFO SAEB:I SWBAWT:I SWBAWTB:I TDA:I TWEMA:I WEMA:I WEMA_AH:O WEMA_AL:O WEMA_IN:I
DI35 VSS TWEMA NDIO12_LP AREA=ARD PJ=PRD
DI30 VSS DA NDIO12_LP AREA=ARD PJ=PRD
DI34 VSS TDA NDIO12_LP AREA=ARD PJ=PRD
DI29 VSS WEMA NDIO12_LP AREA=ARD PJ=PRD
XI5 SAE SAEB me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XI37 NET059 LWE me84a03_INV LN=me84a03_LD LP=me84a03_LD WN=0.15U WP=0.25U
XXSA_DO LQT SQB SQT me84a03_SA_DO1
XXLSA SQB SQT RDT RDB SAE NET060 CCRD me84a03_LSA1
XXDI WRB WRT DCLKB NET42 LWE WEMA_IN me84a03_WRDRV_LITE
XXMX BB3 BB2 BB1 BB0 BT3 BT2 BT1 BT0 RDB RDT WRB WRT PCB3
+PCB2 PCB1 PCB0 me84a03_CMUX4
XXDO NET42 Q WEMA_AH WEMA_AL BCB BCT DA LQT SWBAWT SWBAWTB TDA TWEMA WEMA me84a03_DO
XI27 NET060 SAEB NET059 me84a03_ND2 WN1=0.15U WN2=0.15U WP1=0.15U WP2=0.15U
.ENDS me84a03_IOCM4

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_X1P11CM4                                                             *
* LAST TIME SAVED:  MAY 08 15:23:10 2014                                      *
*******************************************************************************
.SUBCKT me84a03_X1P11CM4 Q3 Q2 Q1 Q0 QM AWT BISTE CLK D3 D2 D1 D0 ME
+RM3 RM2 RM1 RM0 RMDEF2 RMDEF1 RMDEF0 RMEN RMFAST2 RMFAST1
+RMFAST0 RMSLOW2 RMSLOW1 RMSLOW0 RST TCLK TD3 TD2 TD1 TD0 TEST1
+TME TWE TWEM3 TWEM2 TWEM1 TWEM0 TXA6 TXA5 TXA4 TXA3 TXA2
+TXA1 TXA0 TYA1 TYA0 WE WEM3 WEM2 WEM1 WEM0 XA6 XA5 XA4
+XA3 XA2 XA1 XA0 YA1 YA0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD
*.PININFO Q3:O Q2:O Q1:O Q0:O QM:O AWT:I BISTE:I CLK:I D3:I D2:I D1:I D0:I
*.PININFO ME:I RM3:I RM2:I RM1:I RM0:I RMDEF2:I RMDEF1:I RMDEF0:I RMEN:I
*.PININFO RMFAST2:I RMFAST1:I RMFAST0:I RMSLOW2:I RMSLOW1:I RMSLOW0:I RST:I
*.PININFO TCLK:I TD3:I TD2:I TD1:I TD0:I TEST1:I TME:I TWE:I TWEM3:I TWEM2:I
*.PININFO TWEM1:I TWEM0:I TXA6:I TXA5:I TXA4:I TXA3:I TXA2:I TXA1:I
*.PININFO TXA0:I TYA1:I TYA0:I WE:I WEM3:I WEM2:I WEM1:I WEM0:I XA6:I
*.PININFO XA5:I XA4:I XA3:I XA2:I XA1:I XA0:I YA1:I YA0:I
XI19 LOG0 LOG1 me84a03_CAP_RT
XXARRR BBR7 BBR6 BBR5 BBR4 BBR3 BBR2 BBR1 BBR0 BTR7 BTR6
+BTR5 BTR4 BTR3 BTR2 BTR1 BTR0 LOG0 WLR7 WLR6 WLR5 WLR4
+WLR3 WLR2 WLR1 WLR0 me84a03_AR4_RT
XXHSLREF LOG0 RBLRD RBLWR WLR7 WLR6 WLR5 WLR4 WLR3 WLR2 WLR1
+WLR0 me84a03_HSLREF
XXCENTER ACUTRK BCBL BCBR BCTL BCTR CCOR CCRDL CCRD CCWR DCLKBL DCLKBR LWEL LWER
+ MCLK NET230 NET231 PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2
+PARDB1 PARDB0 PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10
+PBRDB9 PBRDB8 PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2
+PBRDB1 PBRDB0 PRCHRDBL3 PRCHRDBL2 PRCHRDBL1 PRCHRDBL0 PRCHRDBR3
+PRCHRDBR2 PRCHRDBR1 PRCHRDBR0 QM NET204 NET227 NET225 RMENB NET202 SAEBL
+SAOFF SWBAWTBL SWBAWTBR SWBAWTL SWBAWTR T1B WCLKRD1 WCLKRD0 WCLKRDB1
+WCLKRDB0 NET119 NET228 Z0B Z2 Z1 Z0 LOG0 LOG1 RM0N RM0N VDD RM0N1 RM0N
+RM1N RM1P1 RM1N RM1N VSS SAEBRT AWT BISTE CLK ME NET225 RMDEF2 RMDEF1
+RMDEF0 RMEN RMENB RMEN RM3 RM2 RM1 RM0 RMFAST2 RMFAST1 RMFAST0
+RMSLOW2 RMSLOW1 RMSLOW0 RST NET231 STCLK STCLKWR NET228 TCLK TEST1 TME
+TWE TXA6 TXA5 TXA4 TXA3 TXA2 TXA1 TXA0 TYA1 TYA0 WE XA6
+XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0 me84a03_CENTER
XIX8DEC WLL7 WLL6 WLL5 WLL4 WLL3 WLL2 WLL1 WLL0 WLR7 WLR6
+WLR5 WLR4 WLR3 WLR2 WLR1 WLR0 ACUTRK VDD VDD WRREF Z2 Z1 Z0
+PARDB7 PARDB6 PARDB5 PARDB4 PARDB3 PARDB2 PARDB1 PARDB0
+PBRDB15 PBRDB14 PBRDB13 PBRDB12 PBRDB11 PBRDB10 PBRDB9 PBRDB8
+PBRDB7 PBRDB6 PBRDB5 PBRDB4 PBRDB3 PBRDB2 PBRDB1 PBRDB0
+WCLKRD1 WCLKRD0 WCLKRDB1 WCLKRDB0 me84a03_X8DEC
XXWAR4L BBL7 BBL6 BBL5 BBL4 BBL3 BBL2 BBL1 BBL0 BTL7 BTL6
+BTL5 BTL4 BTL3 BTL2 BTL1 BTL0 LOG0 LOG1 RWLL RWLL me84a03_WAR4_LT
XXWARREF LOG0 LOG1 RBLRD RBLWR RWLR RWLR me84a03_WARREF
XI20 LOG0 LOG1 me84a03_CAP_LT
XXIO00 BBL0 BBL1 BBL2 BBL3 BCBL BCTL BTL0 BTL1 BTL2 BTL3 CCRDL
+D0 DCLKBL LOG0 LOG1 LWEL PRCHRDBL0 PRCHRDBL1 PRCHRDBL2 PRCHRDBL3 Q0
+SAEBL SWBAWTL SWBAWTBL TD0 TWEM0 WEM0 NET374 NET121 NET374 me84a03_IOCM4
XXIO01 BBL4 BBL5 BBL6 BBL7 BCBL BCTL BTL4 BTL5 BTL6 BTL7 CCRDL
+D1 DCLKBL LOG0 LOG1 LWEL PRCHRDBL0 PRCHRDBL1 PRCHRDBL2 PRCHRDBL3 Q1
+SAEBL SWBAWTL SWBAWTBL TD1 TWEM1 WEM1 NET371 NET120 NET371 me84a03_IOCM4
XXIO04 BBR4 BBR5 BBR6 BBR7 BCBR BCTR BTR4 BTR5 BTR6 BTR7 CCRD
+D3 DCLKBR LOG0 LOG1 LWER PRCHRDBR0 PRCHRDBR1 PRCHRDBR2 PRCHRDBR3 Q3
+SAEB SWBAWTR SWBAWTBR TD3 TWEM3 WEM3 NET366 NET116 NET366 me84a03_IOCM4
XXIO03 BBR0 BBR1 BBR2 BBR3 BCBR BCTR BTR0 BTR1 BTR2 BTR3 CCRD
+D2 DCLKBR LOG0 LOG1 LWER PRCHRDBR0 PRCHRDBR1 PRCHRDBR2 PRCHRDBR3 Q2
+SAEB SWBAWTR SWBAWTBR TD2 TWEM2 WEM2 NET377 NET117 NET377 me84a03_IOCM4
XXRIO BCBR BCTR CCOR CCRD CCWR DCLKBR LOG0 LOG1 LWER MCLK PRCHRDBR0
+PRCHRDBR1 PRCHRDBR2 PRCHRDBR3 RBLRD RBLWR NET118 NET202 SAEB SAEBRT SAOFF
+STCLK STCLKWR SWBAWTR SWBAWTBR T1B WRREF me84a03_RIO_BL
XXRW RWLL RWLR WRREF LOG0 LOG1 RBLRD RBLWR VDD VDD WCLKRD0 WCLKRDB0 ACUTRK
+RWLR Z2 Z1 Z0 me84a03_RW
XXARRL BBL7 BBL6 BBL5 BBL4 BBL3 BBL2 BBL1 BBL0 BTL7 BTL6
+BTL5 BTL4 BTL3 BTL2 BTL1 BTL0 LOG0 WLL7 WLL6 WLL5 WLL4
+WLL3 WLL2 WLL1 WLL0 me84a03_AR4_LT
XXWAR4R BBR7 BBR6 BBR5 BBR4 BBR3 BBR2 BBR1 BBR0 BTR7 BTR6
+BTR5 BTR4 BTR3 BTR2 BTR1 BTR0 LOG0 LOG1 RWLR RWLR me84a03_WAR4_RT
.ENDS me84a03_X1P11CM4

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ALL32A@SHEET001                                                      *
* LAST TIME SAVED:  MAY 08 15:23:04 2014                                      *
*******************************************************************************
.SUBCKT me84a03_ALL32A@SHEET001 Q23 Q22 Q21 Q20 Q33 Q32 Q31 Q30 Q43
+Q42 Q41 Q40 Q53 Q52 Q51 Q50 Q63 Q62 Q61 Q60 Q73 Q72
+Q71 Q70 Q83 Q82 Q81 Q80 Q3 Q2 Q1 Q0 QM QM2 QM5 QM6 AWT
+BISTE CLK D3 D2 D1 D0 ME RM3 RM2 RM1 RM0 RMDEF3 RMDEF2
+RMDEF1 RMDEF0 RMEN RST TCLK TD3 TD2 TD1 TD0 TEST1 TME TWE TWEM3
+TWEM2 TWEM1 TWEM0 TXA6 TXA5 TXA4 TXA3 TXA2 TXA1 TXA0 TYA1
+ TYA0 WE WEM3 WEM2 WEM1 WEM0 XA6 XA5 XA4 XA3 XA2 XA1
+XA0 YA1 YA0 LN=me84a03_LND LN1=me84a03_LND LN2=me84a03_LND LN3=me84a03_LND
+LP=me84a03_LPD LP1=me84a03_LPD LP2=me84a03_LPD LP3=me84a03_LPD
*.PININFO Q23:O Q22:O Q21:O Q20:O Q33:O Q32:O Q31:O Q30:O Q43:O Q42:O
*.PININFO Q41:O Q40:O Q53:O Q52:O Q51:O Q50:O Q63:O Q62:O Q61:O Q60:O
*.PININFO Q73:O Q72:O Q71:O Q70:O Q83:O Q82:O Q81:O Q80:O Q3:O Q2:O
*.PININFO Q1:O Q0:O QM:O QM2:O QM5:O QM6:O AWT:I BISTE:I CLK:I D3:I D2:I D1:I
*.PININFO D0:I ME:I RM3:I RM2:I RM1:I RM0:I RMDEF3:I RMDEF2:I RMDEF1:I
*.PININFO RMDEF0:I RMEN:I RST:I TCLK:I TD3:I TD2:I TD1:I TD0:I TEST1:I TME:I
*.PININFO TWE:I TWEM3:I TWEM2:I TWEM1:I TWEM0:I TXA6:I TXA5:I TXA4:I
*.PININFO TXA3:I TXA2:I TXA1:I TXA0:I TYA1:I TYA0:I WE:I WEM3:I WEM2:I
*.PININFO WEM1:I WEM0:I XA6:I XA5:I XA4:I XA3:I XA2:I XA1:I XA0:I
*.PININFO YA1:I YA0:I
XI540 NET2052 NET2052 NET2054 NET2054 NET1384 NET1399 NET1386 NET1382 NET0249
+NET2050 NET2050 NET2049 NET2049 NET1389 NET1385 me84a03_IOCM2_LITE
XI541 NET2060 NET2060 NET1419 NET1420 NET2062 NET2062 NET1416 NET1435 NET1418
+NET1414 NET0343 NET2058 NET2058 NET2057 NET2057 NET1424 NET1417 NET1422 NET1413
+NET1434 me84a03_IOCM2
XI542 NET2076 NET2076 NET1492 NET1493 NET2078 NET2078 NET1489 NET1507 NET1491
+NET1487 NET0279 NET2074 NET2074 NET2073 NET2073 NET1497 NET1490 NET1495 NET1486
+NET1505 me84a03_IOCM2_LC
XI416 NET2007 NET2007 NET1156 NET1157 NET2011 NET2011 NET1153 NET1207 NET1155
+NET1151 NET0267 NET2001 NET2001 NET2000 NET2000 NET1182 NET1154 NET1159 NET1150
+NET1203 me84a03_IOCM2_LC_8
XI412 NET2006 NET2006 NET1142 NET1143 NET2010 NET2010 NET1139 NET1206 NET1141
+NET1137 NET0288 NET1999 NET1999 NET1998 NET1998 NET1181 NET1140 NET1145 NET1130
+NET1201 NET1192 NET1197 NET1147 NET1146 NET1148 me84a03_IOCM2SW_LC_8
XI413 NET2023 NET2023 NET1229 NET1230 NET2027 NET2027 NET1226 NET1281 NET1228
+NET1224 NET0176 NET2017 NET2017 NET2016 NET2016 NET1260 NET1227 NET1232 NET1223
+NET1278 NET1270 NET1275 NET1234 NET1233 NET1235 me84a03_IOCM2SW_LC_16
XI415 NET2025 NET2025 NET1251 NET1252 NET2029 NET2029 NET1248 NET1283 NET1250
+NET1246 NET0650 NET2021 NET2021 NET2020 NET2020 NET1262 NET1249 NET1254 NET1245
+NET1279 me84a03_IOCM2_LC_16
XI414 NET2040 NET2040 NET1311 NET1312 NET2044 NET2044 NET1308 NET1359 NET1310
+NET1306 NET0346 NET2035 NET2035 NET2034 NET2034 NET1335 NET1309 NET1314 NET1305
+NET1355 NET1347 NET1352 NET1316 NET1315 NET1317 me84a03_IOCM2SW_LC_32
XI418 NET2041 NET2041 NET1324 NET1325 NET2045 NET2045 NET1321 NET1360 NET1323
+NET1319 NET0186 NET2037 NET2037 NET2036 NET2036 NET1336 NET1322 NET1327 NET1318
+NET1356 me84a03_IOCM2_LC_32
XI348 NET2008 NET2008 NET2012 NET2012 NET1165 NET1208 NET1167 NET1163 NET0392
+NET2003 NET2003 NET2002 NET2002 NET1183 NET1166 NET1199 NET1170 NET1169 NET1171
+ me84a03_IOCM2SW_LITE_LC_8
XI347 NET2022 NET2022 NET2026 NET2026 NET1216 NET1280 NET1218 NET1214 NET0407
+NET2015 NET2015 NET2014 NET2014 NET1259 NET1217 NET1274 NET1221 NET1220 NET1222
+ me84a03_IOCM2SW_LITE_LC_16
XI350 NET2038 NET2038 NET2042 NET2042 NET1289 NET1357 NET1291 NET1287 NET0422
+NET2031 NET2031 NET2030 NET2030 NET1332 NET1290 NET1350 NET1294 NET1293 NET1295
+ me84a03_IOCM2SW_LITE_LC_32
XI284 NET2105 NET2105 NET2105 NET2105 NET938 NET939 NET2107 NET2107 NET2107
+NET2107 NET935 NET962 NET937 NET933 NET0464 NET940 NET2101 NET2101 NET2101
+NET2101 NET946 NET936 NET941 NET932 NET960 NET955 NET959 NET943 NET942 NET944
+me84a03_IOCM4_LC_8
XI283 NET2082 NET2082 NET2082 NET2082 NET1010 NET1011 NET2085 NET2085 NET2085
+NET2085 NET1007 NET1037 NET1009 NET1005 NET0485 NET1012 NET2079 NET2079 NET2079
+NET2079 NET1021 NET1008 NET1013 NET1004 NET1034 NET1028 NET1033 NET1015 NET1014
+NET1016 me84a03_IOCM4_LC_16
XI286 NET2090 NET2090 NET2090 NET2090 NET1058 NET1059 NET2093 NET2093 NET2093
+NET2093 NET1055 NET1097 NET1057 NET1053 NET0506 NET1060 NET2087 NET2087 NET2087
+NET2087 NET1080 NET1056 NET1061 NET1052 NET1094 NET1087 NET1091 NET1063 NET1062
+NET1064 me84a03_IOCM4_LC_32
XI282 NET1023 NET1109 NET976 NET977 NET1103 NET968 NET982 NET967 NET1106 NET975
+NET1121 NET964 NET965 NET1124 NET978 NET973 NET1099 NET1112 NET1111 NET11180
+NET11181 NET11182 NET11183 NET11184 NET11185 NET11186 NET11187
+NET11170 NET11171 NET11172 NET11173 NET9660 NET9661 NET9662
+NET9663 NET1125 NET11260 NET11261 NET11262 NET11263 NET11264
+NET11270 NET11271 NET11272 NET11273 NET11274 NET983 NET1104 NET1108
+NET1122 NET1123 NET1102 NET1100 NET9942 NET9941 NET9940 NET1038 NET1129
+NET11280 NET11281 NET10393 NET10392 NET10391 NET10390 NET10222
+NET10221 NET10220 NET10172 NET10171 NET10170 NET1107 NET980 NET971
+NET972 NET1110 NET969 NET970 NET979 NET963 NET1042 NET974 NET1105 NET984
+NET1082 NET1078 NET11150 NET11151 NET11152 NET11153 NET11154
+NET11155 NET11156 NET11160 NET11161 NET11140 NET11141 NET11130
+NET11131 NET1086 NET1040 NET1041 NET11190 NET11191 NET11192 NET11193
+NET11194 NET11195 NET11196 NET11200 NET11201 NET10180 NET981
+NET10181 NET10182 me84a03_CENTER_SD_LC_32
XI266 NET2067 NET2067 NET2069 NET2069 NET1438 NET1459 NET1440 NET1436 NET0131
+NET2064 NET2064 NET2063 NET2063 NET1451 NET1439 NET1456 NET1443 NET1442 NET1444
+ me84a03_IOCM2SW_LITE_LC
XI250 NET2051 NET2051 NET2053 NET2053 NET1375 NET1398 NET1377 NET1373 NET079
+NET2048 NET2048 NET2047 NET2047 NET1388 NET1376 NET1394 NET1380 NET1379 NET1381
+ me84a03_IOCM2SW_LITE
XI234 NET2059 NET2059 NET1406 NET1407 NET2061 NET2061 NET1403 NET1433 NET1405
+NET1401 NET0112 NET2056 NET2056 NET2055 NET2055 NET1423 NET1404 NET1409 NET1400
+NET1431 NET1427 NET1429 NET1411 NET1410 NET1412 me84a03_IOCM2SW
XI217 NET2075 NET2075 NET1479 NET1480 NET2077 NET2077 NET1476 NET1506 NET1478
+NET1474 NET0139 NET2072 NET2072 NET2071 NET2071 NET1496 NET1477 NET1482 NET1473
+NET1504 NET1500 NET1503 NET1484 NET1483 NET1485 me84a03_IOCM2SW_LC
XI140 NET2081 NET2081 NET2081 NET2081 NET2084 NET2084 NET2084 NET2084 NET997
+NET1036 NET999 NET995 NET171 NET1000 NET2109 NET2109 NET2109 NET2109 NET1020
+NET998 NET1032 NET1002 NET1001 NET1003 me84a03_IOCM4_LITE_LC_16
XI171 NET2104 NET2104 NET2104 NET2104 NET2106 NET2106 NET2106 NET2106 NET925
+NET961 NET927 NET923 NET186 NET928 NET2100 NET2100 NET2100 NET2100 NET945
+NET926 NET958 NET930 NET929 NET931 me84a03_IOCM4_LITE_LC_8
XI92 NET2024 NET2024 NET2028 NET2028 NET1238 NET1282 NET1240 NET1236 NET216
+NET2019 NET2019 NET2018 NET2018 NET1261 NET1239 me84a03_IOCM2_LITE_LC_16
XI123 NET2009 NET2009 NET2013 NET2013 NET1174 NET1209 NET1176 NET1172 NET231
+NET2005 NET2005 NET2004 NET2004 NET1184 NET1175 me84a03_IOCM2_LITE_LC_8
XI76 NET2089 NET2089 NET2089 NET2089 NET2092 NET2092 NET2092 NET2092 NET1045
+NET1096 NET1047 NET1043 NET262 NET1048 NET2086 NET2086 NET2086 NET2086 NET1079
+NET1046 NET1090 NET1050 NET1049 NET1051 me84a03_IOCM4_LITE_LC_32
XI9 NET2039 NET2039 NET2043 NET2043 NET1298 NET1358 NET1300 NET1296 NET276
+NET2033 NET2033 NET2032 NET2032 NET1334 NET1299 me84a03_IOCM2_LITE_LC_32
XI25 NET1204 NET313 NET1149 NET297 NET1331 NET1134 NET1366 NET475 NET480 NET1368
+NET1135 NET303 NET1285 NET316 NET1339 NET15160 NET15161 NET15162
+NET15163 NET15164 NET15165 NET15166 NET15167 NET15150 NET15151
+NET15152 NET15153 NET15090 NET15091 NET15092 NET15093 NET0270
+NET13690 NET13691 NET13692 NET13693 NET13694 NET13700 NET13701
+NET13702 NET13703 NET13704 NET01114 NET1337 NET0266 NET1367 NET321
+NET1286 NET15102 NET15101 NET15100 NET1211 NET1372 NET13710 NET13711
+NET2095 NET2095 NET2095 NET2095 NET15122 NET15121 NET15120 NET15112
+NET15111 NET15110 NET1333 NET1136 NET310 NET1133 NET1338 NET1132 NET311
+NET1264 NET324 NET1185 NET15140 NET15141 NET15130 NET15131 NET1284
+NET1258 NET1263 NET2110 NET2110 NET2110 NET2110 NET2110 NET2110 NET2110 NET2046
+NET2046 NET15190 NET1508 NET15191 NET15192 me84a03_CENTER_SD_LITE_LC_32
XI5 Q83 Q82 Q81 Q80 CLK D3 D2 D1 D0 ME RM3 RM2 RM1 RM0
+RMDEF2 RMDEF1 RMDEF0 RMEN RMFAST2 RMFAST1 RMFAST0 RMSLOW2
+RMSLOW1 RMSLOW0 RST TEST1 WE XA6 XA5 XA4 XA3 XA2 XA1 XA0
+YA1 YA0 me84a03_X1P11CM2_LITE_LC
XI4 Q73 Q72 Q71 Q70 CLK D3 D2 D1 D0 ME RM3 RM2 RM1 RM0
+RMDEF2 RMDEF1 RMDEF0 RMEN RMFAST2 RMFAST1 RMFAST0 RMSLOW2
+RMSLOW1 RMSLOW0 RST TEST1 WE WEM3 WEM2 WEM1 WEM0 XA6 XA5 XA4
+XA3 XA2 XA1 XA0 YA1 YA0 me84a03_X1P11CM4_LITE_LC
XI6 Q63 Q62 Q61 Q60 QM6 AWT BISTE CLK D3 D2 D1 D0 ME RM3 RM2
+ RM1 RM0 RMDEF2 RMDEF1 RMDEF0 RMEN RMFAST2 RMFAST1 RMFAST0
+RMSLOW2 RMSLOW1 RMSLOW0 RST TCLK TD3 TD2 TD1 TD0 TEST1 TME TWE
+TXA6 TXA5 TXA4 TXA3 TXA2 TXA1 TXA0 TYA1 TYA0 WE XA6 XA5
+XA4 XA3 XA2 XA1 XA0 YA1 YA0 me84a03_X1P11CM2_LC
XI8 Q53 Q52 Q51 Q50 QM5 AWT BISTE CLK D3 D2 D1 D0 ME RM3 RM2
+ RM1 RM0 NET15182 NET15181 NET15180 RMEN NET15202 NET15201
+NET15200 NET15172 NET15171 NET15170 RST TCLK TD3 TD2 TD1 TD0
+TEST1 TME TWE TWEM3 TWEM2 TWEM1 TWEM0 TXA6 TXA5 TXA4 TXA3
+TXA2 TXA1 TXA0 TYA1 TYA0 WE WEM3 WEM2 WEM1 WEM0 XA6 XA5
+XA4 XA3 XA2 XA1 XA0 YA1 YA0 me84a03_X1P11CM4_LC
XI3 Q43 Q42 Q41 Q40 CLK D3 D2 D1 D0 ME RM3 RM2 RM1 RM0
+NET14712 NET14711 NET14710 RMEN NET14672 NET14671 NET14670
+NET14632 NET14631 NET14630 RST TEST1 WE WEM3 WEM2 WEM1 WEM0 XA6
+ XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0 me84a03_X1P11CM4_LITE
XI2 Q33 Q32 Q31 Q30 CLK D3 D2 D1 D0 ME RM3 RM2 RM1 RM0
+NET14702 NET14701 NET14700 RMEN NET14662 NET14661 NET14660
+NET14622 NET14621 NET14620 RST TEST1 WE XA6 XA5 XA4 XA3 XA2
+XA1 XA0 YA1 YA0 me84a03_X1P11CM2_LITE
XI1 Q23 Q22 Q21 Q20 QM2 AWT BISTE CLK D3 D2 D1 D0 ME RM3 RM2
+ RM1 RM0 NET14692 NET14691 NET14690 RMEN NET14652 NET14651
+NET14650 NET14612 NET14611 NET14610 RST TCLK TD3 TD2 TD1 TD0
+TEST1 TME TWE TXA6 TXA5 TXA4 TXA3 TXA2 TXA1 TXA0 TYA1 TYA0 WE
+ XA6 XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0 me84a03_X1P11CM2
XI0 Q3 Q2 Q1 Q0 QM AWT BISTE CLK D3 D2 D1 D0 ME RM3 RM2
+RM1 RM0 NET14722 NET14721 NET14720 RMEN NET14682 NET14681
+NET14680 NET14642 NET14641 NET14640 RST TCLK TD3 TD2 TD1 TD0
+TEST1 TME TWE TWEM3 TWEM2 TWEM1 TWEM0 TXA6 TXA5 TXA4 TXA3
+TXA2 TXA1 TXA0 TYA1 TYA0 WE WEM3 WEM2 WEM1 WEM0 XA6 XA5
+XA4 XA3 XA2 XA1 XA0 YA1 YA0 me84a03_X1P11CM4
XI604 NET2097 NET2097 NET2097 NET2097 NET2098 NET2098 NET2098 NET2098 NET897
+NET908 NET899 NET895 NET0344 NET900 NET2096 NET2096 NET2096 NET2096 NET904
+NET898 NET907 NET902 NET901 NET903 me84a03_IOCM4_LITE
XI605 NET2102 NET2102 NET2102 NET2102 NET915 NET916 NET2103 NET2103 NET2103
+NET2103 NET912 NET954 NET914 NET910 NET0388 NET917 NET2099 NET2099 NET2099
+NET2099 NET922 NET913 NET918 NET909 NET953 NET948 NET950 NET920 NET919 NET921
+me84a03_IOCM4
XI603 NET2080 NET2080 NET2080 NET2080 NET2083 NET2083 NET2083 NET2083 NET987
+NET1035 NET989 NET985 NET0306 NET990 NET2108 NET2108 NET2108 NET2108 NET1019
+NET988 NET1031 NET992 NET991 NET993 me84a03_IOCM4_LITE_LC
XI606 NET2091 NET2091 NET2091 NET2091 NET1071 NET1072 NET2094 NET2094 NET2094
+NET2094 NET1068 NET1101 NET1070 NET1066 NET0484 NET1073 NET2088 NET2088 NET2088
+NET2088 NET1081 NET1069 NET1074 NET1065 NET1098 NET1092 NET1095 NET1076 NET1075
+NET1077 me84a03_IOCM4_LC
XI539 NET2068 NET2068 NET2070 NET2070 NET1447 NET1460 NET1449 NET1445 NET0360
+NET2066 NET2066 NET2065 NET2065 NET1452 NET1448 me84a03_IOCM2_LITE_LC
.ENDS me84a03_ALL32A@SHEET001

*******************************************************************************
* SUB-CIRCUIT NETLIST:                                                        *
*                                                                             *
* BLOCK: me84a03_ALL32A                                                               *
* LAST TIME SAVED:  MAY 08 15:22:49 2014                                      *
*******************************************************************************
.SUBCKT me84a03_ALL32A Q23 Q22 Q21 Q20 Q33 Q32 Q31 Q30 Q43 Q42 Q41
+ Q40 Q53 Q52 Q51 Q50 Q63 Q62 Q61 Q60 Q73 Q72 Q71 Q70
+Q83 Q82 Q81 Q80 Q3 Q2 Q1 Q0 QM QM2 QM5 QM6 AWT BISTE CLK D3
+D2 D1 D0 ME RM3 RM2 RM1 RM0 RMDEF3 RMDEF2 RMDEF1 RMDEF0
+RMEN RST TCLK TD3 TD2 TD1 TD0 TEST1 TME TWE TWEM3 TWEM2 TWEM1
+TWEM0 TXA6 TXA5 TXA4 TXA3 TXA2 TXA1 TXA0 TYA1 TYA0 WE
+WEM3 WEM2 WEM1 WEM0 XA6 XA5 XA4 XA3 XA2 XA1 XA0 YA1
+YA0
*.PININFO Q23:O Q22:O Q21:O Q20:O Q33:O Q32:O Q31:O Q30:O Q43:O Q42:O
*.PININFO Q41:O Q40:O Q53:O Q52:O Q51:O Q50:O Q63:O Q62:O Q61:O Q60:O
*.PININFO Q73:O Q72:O Q71:O Q70:O Q83:O Q82:O Q81:O Q80:O Q3:O Q2:O
*.PININFO Q1:O Q0:O QM:O QM2:O QM5:O QM6:O AWT:I BISTE:I CLK:I D3:I D2:I D1:I
*.PININFO D0:I ME:I RM3:I RM2:I RM1:I RM0:I RMDEF3:I RMDEF2:I RMDEF1:I
*.PININFO RMDEF0:I RMEN:I RST:I TCLK:I TD3:I TD2:I TD1:I TD0:I TEST1:I TME:I
*.PININFO TWE:I TWEM3:I TWEM2:I TWEM1:I TWEM0:I TXA6:I TXA5:I TXA4:I
*.PININFO TXA3:I TXA2:I TXA1:I TXA0:I TYA1:I TYA0:I WE:I WEM3:I WEM2:I
*.PININFO WEM1:I WEM0:I XA6:I XA5:I XA4:I XA3:I XA2:I XA1:I XA0:I
*.PININFO YA1:I YA0:I
XSH2 me84a03_ALL32A@SHEET002
XSH1 Q23 Q22 Q21 Q20 Q33 Q32 Q31 Q30 Q43 Q42 Q41 Q40
+Q53 Q52 Q51 Q50 Q63 Q62 Q61 Q60 Q73 Q72 Q71 Q70 Q83
+Q82 Q81 Q80 Q3 Q2 Q1 Q0 QM QM2 QM5 QM6 AWT BISTE CLK D3 D2
+D1 D0 ME RM3 RM2 RM1 RM0 RMDEF3 RMDEF2 RMDEF1 RMDEF0 RMEN
+RST TCLK TD3 TD2 TD1 TD0 TEST1 TME TWE TWEM3 TWEM2 TWEM1 TWEM0
+TXA6 TXA5 TXA4 TXA3 TXA2 TXA1 TXA0 TYA1 TYA0 WE WEM3 WEM2
+WEM1 WEM0 XA6 XA5 XA4 XA3 XA2 XA1 XA0 YA1 YA0
+me84a03_ALL32A@SHEET001
.ENDS me84a03_ALL32A

.SUBCKT  asdrlspkb1p64x16cm2sw0_bld_arr_rt LOG0 LOG1 BB[31] BB[30] BB[29] BB[28]
+    BB[27] BB[26] BB[25] BB[24] BB[23] BB[22] BB[21] BB[20] BB[19] BB[18]
+   BB[17] BB[16] BB[15] BB[14] BB[13] BB[12] BB[11] BB[10] BB[9] BB[8] BB[7]
+   BB[6] BB[5] BB[4] BB[3] BB[2] BB[1] BB[0] BT[31] BT[30] BT[29] BT[28] BT[27]
+    BT[26] BT[25] BT[24] BT[23] BT[22] BT[21] BT[20] BT[19] BT[18] BT[17]
+   BT[16] BT[15] BT[14] BT[13] BT[12] BT[11] BT[10] BT[9] BT[8] BT[7] BT[6]
+   BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[1] WL[0]
X_colrt0 BB[0] BB[1] BT[0] BT[1] WL[0] WL[1] me84a03_BAR2
X_colrt1 BB[2] BB[3] BT[2] BT[3] WL[0] WL[1] me84a03_BAR2
X_colrt2 BB[4] BB[5] BT[4] BT[5] WL[0] WL[1] me84a03_BAR2
X_colrt3 BB[6] BB[7] BT[6] BT[7] WL[0] WL[1] me84a03_BAR2
X_colrt4 BB[8] BB[9] BT[8] BT[9] WL[0] WL[1] me84a03_BAR2
X_colrt5 BB[10] BB[11] BT[10] BT[11] WL[0] WL[1] me84a03_BAR2
X_colrt6 BB[12] BB[13] BT[12] BT[13] WL[0] WL[1] me84a03_BAR2
X_colrt7 BB[14] BB[15] BT[14] BT[15] WL[0] WL[1] me84a03_BAR2
X_colrt8 BB[16] BB[17] BT[16] BT[17] WL[0] WL[1] me84a03_BAR2
X_colrt9 BB[18] BB[19] BT[18] BT[19] WL[0] WL[1] me84a03_BAR2
X_colrt10 BB[20] BB[21] BT[20] BT[21] WL[0] WL[1] me84a03_BAR2
X_colrt11 BB[22] BB[23] BT[22] BT[23] WL[0] WL[1] me84a03_BAR2
X_colrt12 BB[24] BB[25] BT[24] BT[25] WL[0] WL[1] me84a03_BAR2
X_colrt13 BB[26] BB[27] BT[26] BT[27] WL[0] WL[1] me84a03_BAR2
X_colrt14 BB[28] BB[29] BT[28] BT[29] WL[0] WL[1] me84a03_BAR2
X_colrt15 BB[30] BB[31] BT[30] BT[31] WL[0] WL[1] me84a03_BAR2
X_core_endr WL[0] WL[1] me84a03_RAM_EDGE2
.ENDS
.SUBCKT  asdrlspkb1p64x16cm2sw0_bld_strap_rt LOG0 LOG1
X_straprt0 LOG0 me84a03_STRAP2
X_straprt1 LOG0 me84a03_STRAP2
X_straprt2 LOG0 me84a03_STRAP2
X_straprt3 LOG0 me84a03_STRAP2
X_straprt4 LOG0 me84a03_STRAP2
X_straprt5 LOG0 me84a03_STRAP2
X_straprt6 LOG0 me84a03_STRAP2
X_straprt7 LOG0 me84a03_STRAP2
X_straprt8 LOG0 me84a03_STRAP2
X_straprt9 LOG0 me84a03_STRAP2
X_straprt10 LOG0 me84a03_STRAP2
X_straprt11 LOG0 me84a03_STRAP2
X_straprt12 LOG0 me84a03_STRAP2
X_straprt13 LOG0 me84a03_STRAP2
X_straprt14 LOG0 me84a03_STRAP2
X_straprt15 LOG0 me84a03_STRAP2
.ENDS
.SUBCKT  asdrlspkb1p64x16cm2sw0_bld_strap_rt_bot LOG0 LOG1
X_straprt0 LOG0 me84a03_STRAP2_BOT
X_straprt1 LOG0 me84a03_STRAP2_BOT
X_straprt2 LOG0 me84a03_STRAP2_BOT
X_straprt3 LOG0 me84a03_STRAP2_BOT
X_straprt4 LOG0 me84a03_STRAP2_BOT
X_straprt5 LOG0 me84a03_STRAP2_BOT
X_straprt6 LOG0 me84a03_STRAP2_BOT
X_straprt7 LOG0 me84a03_STRAP2_BOT
X_straprt8 LOG0 me84a03_STRAP2_BOT
X_straprt9 LOG0 me84a03_STRAP2_BOT
X_straprt10 LOG0 me84a03_STRAP2_BOT
X_straprt11 LOG0 me84a03_STRAP2_BOT
X_straprt12 LOG0 me84a03_STRAP2_BOT
X_straprt13 LOG0 me84a03_STRAP2_BOT
X_straprt14 LOG0 me84a03_STRAP2_BOT
X_straprt15 LOG0 me84a03_STRAP2_BOT
.ENDS
.SUBCKT  asdrlspkb1p64x16cm2sw0_array_rt LOG0 LOG1 BB[31] BB[30] BB[29] BB[28]
+   BB[27] BB[26] BB[25] BB[24] BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17]
+    BB[16] BB[15] BB[14] BB[13] BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6]
+   BB[5] BB[4] BB[3] BB[2] BB[1] BB[0] BT[31] BT[30] BT[29] BT[28] BT[27]
+   BT[26] BT[25] BT[24] BT[23] BT[22] BT[21] BT[20] BT[19] BT[18] BT[17] BT[16]
+    BT[15] BT[14] BT[13] BT[12] BT[11] BT[10] BT[9] BT[8] BT[7] BT[6] BT[5]
+   BT[4] BT[3] BT[2] BT[1] BT[0] WL[31] WL[30] WL[29] WL[28] WL[27] WL[26]
+   WL[25] WL[24] WL[23] WL[22] WL[21] WL[20] WL[19] WL[18] WL[17] WL[16] WL[15]
+    WL[14] WL[13] WL[12] WL[11] WL[10] WL[9] WL[8] WL[7] WL[6] WL[5] WL[4]
+   WL[3] WL[2] WL[1] WL[0]
X_rowrt0 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[1]
+   WL[0] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt1 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[3]
+   WL[2] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt2 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[5]
+   WL[4] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt3 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[7]
+   WL[6] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt4 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[9]
+   WL[8] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt5 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[11]
+   WL[10] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt6 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[13]
+   WL[12] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt7 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[15]
+   WL[14] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt8 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[17]
+   WL[16] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt9 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[19]
+   WL[18] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt10 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[21]
+   WL[20] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt11 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[23]
+   WL[22] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt12 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[25]
+   WL[24] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt13 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[27]
+   WL[26] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt14 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[29]
+   WL[28] asdrlspkb1p64x16cm2sw0_bld_arr_rt
X_rowrt15 LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WL[31]
+   WL[30] asdrlspkb1p64x16cm2sw0_bld_arr_rt
Xstrap_rtop LOG0 LOG1 asdrlspkb1p64x16cm2sw0_bld_strap_rt_bot
Xstrap_rbot LOG0 LOG1 asdrlspkb1p64x16cm2sw0_bld_strap_rt
Xstrap_rtop1 LOG0 LOG1 asdrlspkb1p64x16cm2sw0_bld_strap_rt
.ENDS
.SUBCKT  asdrlspkb1p64x16cm2sw0_refar LOG0 LOG1 WL[31] WL[30] WL[29] WL[28]
+   WL[27] WL[26] WL[25] WL[24] WL[23] WL[22] WL[21] WL[20] WL[19] WL[18] WL[17]
+    WL[16] WL[15] WL[14] WL[13] WL[12] WL[11] WL[10] WL[9] WL[8] WL[7] WL[6]
+   WL[5] WL[4] WL[3] WL[2] WL[1] WL[0] RBLRD RBLWR
X_refrow0 LOG0 RBLRD RBLWR WL[0] WL[1] net_lref_[0] net_lref_[1] me84a03_HS2LREF
X_refrow1 LOG0 RBLRD RBLWR WL[2] WL[3] net_lref_[1] net_lref_[2] me84a03_HS2LREF
X_refrow2 LOG0 RBLRD RBLWR WL[4] WL[5] net_lref_[2] net_lref_[3] me84a03_HS2LREF
X_refrow3 LOG0 RBLRD RBLWR WL[6] WL[7] net_lref_[3] net_lref_[4] me84a03_HS2LREF
X_refrow4 LOG0 RBLRD RBLWR WL[8] WL[9] net_lref_[4] net_lref_[5] me84a03_HS2LREF
X_refrow5 LOG0 RBLRD RBLWR WL[10] WL[11] net_lref_[5] net_lref_[6]
+   me84a03_HS2LREF
X_refrow6 LOG0 RBLRD RBLWR WL[12] WL[13] net_lref_[6] net_lref_[7]
+   me84a03_HS2LREF
X_refrow7 LOG0 RBLRD RBLWR WL[14] WL[15] net_lref_[7] net_lref_[8]
+   me84a03_HS2LREF
X_refrow8 LOG0 RBLRD RBLWR WL[16] WL[17] net_lref_[8] net_lref_[9]
+   me84a03_HS2LREF
X_refrow9 LOG0 RBLRD RBLWR WL[18] WL[19] net_lref_[9] net_lref_[10]
+   me84a03_HS2LREF
X_refrow10 LOG0 RBLRD RBLWR WL[20] WL[21] net_lref_[10] net_lref_[11]
+   me84a03_HS2LREF
X_refrow11 LOG0 RBLRD RBLWR WL[22] WL[23] net_lref_[11] net_lref_[12]
+   me84a03_HS2LREF
X_refrow12 LOG0 RBLRD RBLWR WL[24] WL[25] net_lref_[12] net_lref_[13]
+   me84a03_HS2LREF
X_refrow13 LOG0 RBLRD RBLWR WL[26] WL[27] net_lref_[13] net_lref_[14]
+   me84a03_HS2LREF
X_refrow15 LOG0 RBLRD RBLWR WL[28] WL[29] net_lref_[15] net_lref_[16]
+   me84a03_HS2LREF
X_refrow16 LOG0 RBLRD RBLWR WL[30] WL[31] net_lref_[16] net_lref_[17]
+   me84a03_HS2LREF
Xstrap_reft LOG0 me84a03_STRAP_BOT
Xstrap_reft1 LOG0 me84a03_STRAP
Xstrap_refb LOG0 me84a03_STRAP
.ENDS
.SUBCKT  asdrlspkb1p64x16cm2sw0_xdec_top LOG0 LOG1 WLL[31] WLL[30] WLL[29]
+   WLL[28] WLL[27] WLL[26] WLL[25] WLL[24] WLL[23] WLL[22] WLL[21] WLL[20]
+   WLL[19] WLL[18] WLL[17] WLL[16] WLL[15] WLL[14] WLL[13] WLL[12] WLL[11]
+   WLL[10] WLL[9] WLL[8] WLL[7] WLL[6] WLL[5] WLL[4] WLL[3] WLL[2] WLL[1]
+   WLL[0] WLR[31] WLR[30] WLR[29] WLR[28] WLR[27] WLR[26] WLR[25] WLR[24]
+   WLR[23] WLR[22] WLR[21] WLR[20] WLR[19] WLR[18] WLR[17] WLR[16] WLR[15]
+   WLR[14] WLR[13] WLR[12] WLR[11] WLR[10] WLR[9] WLR[8] WLR[7] WLR[6] WLR[5]
+   WLR[4] WLR[3] WLR[2] WLR[1] WLR[0] PARDB[7] PARDB[6] PARDB[5] PARDB[4]
+   PARDB[3] PARDB[2] PARDB[1] PARDB[0] PBRDB[15] PBRDB[14] PBRDB[13] PBRDB[12]
+   PBRDB[11] PBRDB[10] PBRDB[9] PBRDB[8] PBRDB[7] PBRDB[6] PBRDB[5] PBRDB[4]
+   PBRDB[3] PBRDB[2] PBRDB[1] PBRDB[0] WCLKRD[1] WCLKRD[0] WCLKRDB[1]
+   WCLKRDB[0] RDOFF WRREF
X_xdec0 PARDB[0] PARDB[1] PBRDB[0] VDDR WCLKRD[0] WCLKRDB[0] WCLKRDB[1] WLL[1]
+   WLL[0] WLR[1] WLR[0] WRREF me84a03_X2DEC_SD_LC
X_xdec2 PARDB[4] PARDB[5] PBRDB[0] VDDR WCLKRD[1] WCLKRDB[0] WCLKRDB[1] WLL[5]
+   WLL[4] WLR[5] WLR[4] WRREF me84a03_X2DEC_SD_LC
X_xdec4 PARDB[0] PARDB[1] PBRDB[1] VDDR WCLKRD[0] WCLKRDB[0] WCLKRDB[1] WLL[9]
+   WLL[8] WLR[9] WLR[8] WRREF me84a03_X2DEC_SD_LC
X_xdec6 PARDB[4] PARDB[5] PBRDB[1] VDDR WCLKRD[1] WCLKRDB[0] WCLKRDB[1] WLL[13]
+   WLL[12] WLR[13] WLR[12] WRREF me84a03_X2DEC_SD_LC
X_xdec8 PARDB[0] PARDB[1] PBRDB[2] VDDR WCLKRD[0] WCLKRDB[0] WCLKRDB[1] WLL[17]
+   WLL[16] WLR[17] WLR[16] WRREF me84a03_X2DEC_SD_LC
X_xdec10 PARDB[4] PARDB[5] PBRDB[2] VDDR WCLKRD[1] WCLKRDB[0] WCLKRDB[1] WLL[21]
+    WLL[20] WLR[21] WLR[20] WRREF me84a03_X2DEC_SD_LC
X_xdec12 PARDB[0] PARDB[1] PBRDB[3] VDDR WCLKRD[0] WCLKRDB[0] WCLKRDB[1] WLL[25]
+    WLL[24] WLR[25] WLR[24] WRREF me84a03_X2DEC_SD_LC
X_xdec14 PARDB[4] PARDB[5] PBRDB[3] VDDR WCLKRD[1] WCLKRDB[0] WCLKRDB[1] WLL[29]
+    WLL[28] WLR[29] WLR[28] WRREF me84a03_X2DEC_SD_LC
X_xdec1 PARDB[2] PARDB[3] PBRDB[0] VDDR WCLKRD[0] WCLKRDB[0] WCLKRDB[1] WLL[2]
+   WLL[3] WLR[2] WLR[3] WRREF me84a03_X2DEC_SD_LC
X_xdec3 PARDB[6] PARDB[7] PBRDB[0] VDDR WCLKRD[1] WCLKRDB[0] WCLKRDB[1] WLL[6]
+   WLL[7] WLR[6] WLR[7] WRREF me84a03_X2DEC_SD_LC
X_xdec5 PARDB[2] PARDB[3] PBRDB[1] VDDR WCLKRD[0] WCLKRDB[0] WCLKRDB[1] WLL[10]
+   WLL[11] WLR[10] WLR[11] WRREF me84a03_X2DEC_SD_LC
X_xdec7 PARDB[6] PARDB[7] PBRDB[1] VDDR WCLKRD[1] WCLKRDB[0] WCLKRDB[1] WLL[14]
+   WLL[15] WLR[14] WLR[15] WRREF me84a03_X2DEC_SD_LC
X_xdec9 PARDB[2] PARDB[3] PBRDB[2] VDDR WCLKRD[0] WCLKRDB[0] WCLKRDB[1] WLL[18]
+   WLL[19] WLR[18] WLR[19] WRREF me84a03_X2DEC_SD_LC
X_xdec11 PARDB[6] PARDB[7] PBRDB[2] VDDR WCLKRD[1] WCLKRDB[0] WCLKRDB[1] WLL[22]
+    WLL[23] WLR[22] WLR[23] WRREF me84a03_X2DEC_SD_LC
X_xdec13 PARDB[2] PARDB[3] PBRDB[3] VDDR WCLKRD[0] WCLKRDB[0] WCLKRDB[1] WLL[26]
+    WLL[27] WLR[26] WLR[27] WRREF me84a03_X2DEC_SD_LC
X_xdec15 PARDB[6] PARDB[7] PBRDB[3] VDDR WCLKRD[1] WCLKRDB[0] WCLKRDB[1] WLL[30]
+    WLL[31] WLR[30] WLR[31] WRREF me84a03_X2DEC_SD_LC
XPGB RDOFF VDDR INTB WRREF me84a03_XDEC_SD_PG
XPGT RDOFF VDDR INT WRREF me84a03_XDEC_SD_PG
.ENDS
.SUBCKT  asdrlspkb1p64x16cm2sw0_war_blk_rt LOG0 LOG1 BB[31] BB[30] BB[29] BB[28]
+    BB[27] BB[26] BB[25] BB[24] BB[23] BB[22] BB[21] BB[20] BB[19] BB[18]
+   BB[17] BB[16] BB[15] BB[14] BB[13] BB[12] BB[11] BB[10] BB[9] BB[8] BB[7]
+   BB[6] BB[5] BB[4] BB[3] BB[2] BB[1] BB[0] BT[31] BT[30] BT[29] BT[28] BT[27]
+    BT[26] BT[25] BT[24] BT[23] BT[22] BT[21] BT[20] BT[19] BT[18] BT[17]
+   BT[16] BT[15] BT[14] BT[13] BT[12] BT[11] BT[10] BT[9] BT[8] BT[7] BT[6]
+   BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] RWL RBLRD RBLWR
X_war_end_r LOG0 LOG1 RBLRD RBLWR RWL RWL me84a03_WARREF
X_warrt_blk0 BB[0] BB[1] BT[0] BT[1] LOG0 LOG1 RWL RWL me84a03_BWAR2
X_warrt_blk1 BB[2] BB[3] BT[2] BT[3] LOG0 LOG1 RWL RWL me84a03_BWAR2
X_warrt_blk2 BB[4] BB[5] BT[4] BT[5] LOG0 LOG1 RWL RWL me84a03_BWAR2
X_warrt_blk3 BB[6] BB[7] BT[6] BT[7] LOG0 LOG1 RWL RWL me84a03_BWAR2
X_warrt_blk4 BB[8] BB[9] BT[8] BT[9] LOG0 LOG1 RWL RWL me84a03_BWAR2
X_warrt_blk5 BB[10] BB[11] BT[10] BT[11] LOG0 LOG1 RWL RWL me84a03_BWAR2
X_warrt_blk6 BB[12] BB[13] BT[12] BT[13] LOG0 LOG1 RWL RWL me84a03_BWAR2
X_warrt_blk7 BB[14] BB[15] BT[14] BT[15] LOG0 LOG1 RWL RWL me84a03_BWAR2_RET
X_warrt_blk8 BB[16] BB[17] BT[16] BT[17] LOG0 LOG1 LOG0 LOG0 me84a03_BWAR2
X_warrt_blk9 BB[18] BB[19] BT[18] BT[19] LOG0 LOG1 LOG0 LOG0 me84a03_BWAR2
X_warrt_blk10 BB[20] BB[21] BT[20] BT[21] LOG0 LOG1 LOG0 LOG0 me84a03_BWAR2
X_warrt_blk11 BB[22] BB[23] BT[22] BT[23] LOG0 LOG1 LOG0 LOG0 me84a03_BWAR2
X_warrt_blk12 BB[24] BB[25] BT[24] BT[25] LOG0 LOG1 LOG0 LOG0 me84a03_BWAR2
X_warrt_blk13 BB[26] BB[27] BT[26] BT[27] LOG0 LOG1 LOG0 LOG0 me84a03_BWAR2
X_warrt_blk14 BB[28] BB[29] BT[28] BT[29] LOG0 LOG1 LOG0 LOG0 me84a03_BWAR2
X_warrt_blk15 BB[30] BB[31] BT[30] BT[31] LOG0 LOG1 LOG0 LOG0 me84a03_BWAR2
X_war_end_l LOG0 LOG0 me84a03_RAM_EDGE2
.ENDS
.SUBCKT  asdrlspkb1p64x16cm2sw0_io_rt LOG0 LOG1 Q[15] Q[14] Q[13] Q[12] Q[11]
+   Q[10] Q[9] Q[8] Q[7] Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] BB[31] BB[30] BB[29]
+    BB[28] BB[27] BB[26] BB[25] BB[24] BB[23] BB[22] BB[21] BB[20] BB[19]
+   BB[18] BB[17] BB[16] BB[15] BB[14] BB[13] BB[12] BB[11] BB[10] BB[9] BB[8]
+   BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1] BB[0] BT[31] BT[30] BT[29] BT[28]
+   BT[27] BT[26] BT[25] BT[24] BT[23] BT[22] BT[21] BT[20] BT[19] BT[18] BT[17]
+    BT[16] BT[15] BT[14] BT[13] BT[12] BT[11] BT[10] BT[9] BT[8] BT[7] BT[6]
+   BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] CCOR CCRD CCWR DA[15] DA[14] DA[13]
+   DA[12] DA[11] DA[10] DA[9] DA[8] DA[7] DA[6] DA[5] DA[4] DA[3] DA[2] DA[1]
+   DA[0] DCLKB LWE MCLK PCB[3] PCB[2] PCB[1] PCB[0] RBLRD RBLWR RW_RBL RT1
+   SAEBRT SAOFF STCLK STCLKWR T1B WRREF
XRIO CCOR CCRD CCWR DCLKB LOG0 LOG1 LWE MCLK PCB[0] PCB[1] PCB[2] PCB[3] RBLRD
+   RBLWR RT1 RW_RBL SAEB SAEBRT SAOFF STCLK STCLKWR T1B WRREF
+   me84a03_RIO_BL_LITE
Xio_rt0 BB[0] BB[1] BT[0] BT[1] CCRD DA[0] DCLKB LOG0 LOG1 LWE LWE PCB[0] PCB[1]
+    Q[0] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt2 BB[4] BB[5] BT[4] BT[5] CCRD DA[2] DCLKB LOG0 LOG1 LWE LWE PCB[0] PCB[1]
+    Q[2] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt4 BB[8] BB[9] BT[8] BT[9] CCRD DA[4] DCLKB LOG0 LOG1 LWE LWE PCB[0] PCB[1]
+    Q[4] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt6 BB[12] BB[13] BT[12] BT[13] CCRD DA[6] DCLKB LOG0 LOG1 LWE LWE PCB[0]
+   PCB[1] Q[6] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt8 BB[16] BB[17] BT[16] BT[17] CCRD DA[8] DCLKB LOG0 LOG1 LWE LWE PCB[0]
+   PCB[1] Q[8] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt10 BB[20] BB[21] BT[20] BT[21] CCRD DA[10] DCLKB LOG0 LOG1 LWE LWE PCB[0]
+   PCB[1] Q[10] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt12 BB[24] BB[25] BT[24] BT[25] CCRD DA[12] DCLKB LOG0 LOG1 LWE LWE PCB[0]
+   PCB[1] Q[12] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt14 BB[28] BB[29] BT[28] BT[29] CCRD DA[14] DCLKB LOG0 LOG1 LWE LWE PCB[0]
+   PCB[1] Q[14] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt1 BB[3] BB[2] BT[3] BT[2] CCRD DA[1] DCLKB LOG0 LOG1 LWE LWE PCB[3] PCB[2]
+    Q[1] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt3 BB[7] BB[6] BT[7] BT[6] CCRD DA[3] DCLKB LOG0 LOG1 LWE LWE PCB[3] PCB[2]
+    Q[3] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt5 BB[11] BB[10] BT[11] BT[10] CCRD DA[5] DCLKB LOG0 LOG1 LWE LWE PCB[3]
+   PCB[2] Q[5] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt7 BB[15] BB[14] BT[15] BT[14] CCRD DA[7] DCLKB LOG0 LOG1 LWE LWE PCB[3]
+   PCB[2] Q[7] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt9 BB[19] BB[18] BT[19] BT[18] CCRD DA[9] DCLKB LOG0 LOG1 LWE LWE PCB[3]
+   PCB[2] Q[9] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt11 BB[23] BB[22] BT[23] BT[22] CCRD DA[11] DCLKB LOG0 LOG1 LWE LWE PCB[3]
+   PCB[2] Q[11] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt13 BB[27] BB[26] BT[27] BT[26] CCRD DA[13] DCLKB LOG0 LOG1 LWE LWE PCB[3]
+   PCB[2] Q[13] SAEB me84a03_IOCM2_LITE_LC_32
Xio_rt15 BB[31] BB[30] BT[31] BT[30] CCRD DA[15] DCLKB LOG0 LOG1 LWE LWE PCB[3]
+   PCB[2] Q[15] SAEB me84a03_IOCM2_LITE_LC_32
XCAP1K LOG0 LOG1 me84a03_CAP_RT
.ENDS
.SUBCKT  asdrlspkb1p64x16cm2sw0_gcen_with_prog LOG0 LOG1 ACUTRK CCOR CCRDR
+   DCLKBR MCLK LWER PARDB[7] PARDB[6] PARDB[5] PARDB[4] PARDB[3] PARDB[2]
+   PARDB[1] PARDB[0] PBRDB[3] PBRDB[2] PBRDB[1] PBRDB[0] PCBR[3] PCBR[2]
+   PCBR[1] PCBR[0] RDOFF RW_RBL SAOFF T1B WCLKRD[1] WCLKRD[0] WCLKRDB[1]
+   WCLKRDB[0] Z0B Z[2] Z[1] Z[0] ADRRD[5] ADRRD[4] ADRRD[3] ADRRD[2] ADRRD[1]
+   ADRRD[0] CLK CCWR ME RMDEF[2] RMDEF[1] RMDEF[0] RMEN RMEXT[3] RMEXT[2]
+   RMEXT[1] RMEXT[0] RMFAST[2] RMFAST[1] RMFAST[0] RMSLOW[2] RMSLOW[1]
+   RMSLOW[0] SAEBRT STCLK STCLKWR TEST1 WE
Xgcen ACUTRK CCOR CCRDR CCWR CLK DCLKBR FLOATI LOG0 LOG1 LWEI LWER MCLK ME
+   MERDA0 MERDA1 PARDB[0] PARDB[1] PARDB[2] PARDB[3] PARDB[4] PARDB[5] PARDB[6]
+    PARDB[7] PBRDB[0] PBRDB[1] PBRDB[2] PBRDB[3] PCBR[0] PCBR[1] PCBR[2]
+   PCBR[3] PRCLK RM0N RM0N1 VDD RM0N RM0N VSS RM1N RM1N RM1P1 RM1N RLYA1QB
+   RDOFF RLYA0QB RLYA0QT RLYA1QB RLYA1QT RMDEF[0] RMDEF[1] RMDEF[2] RMEN RMENB
+   RMEN RMENB RMEXT[0] RMEXT[1] RMEXT[2] RMEXT[3] RMFAST[0] RMFAST[1] RMFAST[2]
+    RMSLOW[0] RMSLOW[1] RMSLOW[2] LOG0 RW_RBL SAEBRT SAOFF MERDA1 STCLK STCLKWR
+    WEA1 T1B TEST1 WCLKRD[0] WCLKRD[1] WCLKRDB[0] WCLKRDB[1] WE WEA0 WEA1
+   ADRRD[1] ADRRD[2] ADRRD[3] ADRRD[4] ADRRD[5] LOG0 LOG0 ADRRD[0] LOG0 Z[0]
+   Z0B Z[1] Z[2] me84a03_CENTER_SD_LITE_LC_32
.ENDS
.SUBCKT  asdrlspkb1p64x16cm2sw0 Q[15] Q[14] Q[13] Q[12] Q[11] Q[10] Q[9] Q[8]
+   Q[7] Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] ADR[5] ADR[4] ADR[3] ADR[2] ADR[1]
+   ADR[0] D[15] D[14] D[13] D[12] D[11] D[10] D[9] D[8] D[7] D[6] D[5] D[4]
+   D[3] D[2] D[1] D[0] WE ME CLK TEST1 RME RM[3] RM[2] RM[1] RM[0]
Xrw ACUTRK LOG0 LOG1 RBLRD RBLWR RWLR RWLR VDD WCLKRD[0] WCLKRDB[0] WLBRW WRREF
+   Z[0] Z[1] Z[2] me84a03_RW_SD_LC
Xwar_rt LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24] BB[23]
+    BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+   BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] RWLR
+   RBLRD RBLWR asdrlspkb1p64x16cm2sw0_war_blk_rt
Xarray_rt LOG0 LOG1 BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25] BB[24]
+   BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14] BB[13]
+    BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2] BB[1]
+   BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23] BT[22]
+   BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12] BT[11]
+    BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0] WLR[31]
+   WLR[30] WLR[29] WLR[28] WLR[27] WLR[26] WLR[25] WLR[24] WLR[23] WLR[22]
+   WLR[21] WLR[20] WLR[19] WLR[18] WLR[17] WLR[16] WLR[15] WLR[14] WLR[13]
+   WLR[12] WLR[11] WLR[10] WLR[9] WLR[8] WLR[7] WLR[6] WLR[5] WLR[4] WLR[3]
+   WLR[2] WLR[1] WLR[0] asdrlspkb1p64x16cm2sw0_array_rt
Xrefar_rt LOG0 LOG1 WLR[31] WLR[30] WLR[29] WLR[28] WLR[27] WLR[26] WLR[25]
+   WLR[24] WLR[23] WLR[22] WLR[21] WLR[20] WLR[19] WLR[18] WLR[17] WLR[16]
+   WLR[15] WLR[14] WLR[13] WLR[12] WLR[11] WLR[10] WLR[9] WLR[8] WLR[7] WLR[6]
+   WLR[5] WLR[4] WLR[3] WLR[2] WLR[1] WLR[0] RBLRD RBLWR
+   asdrlspkb1p64x16cm2sw0_refar
Xxdec_top LOG0 LOG1 WLL[31] WLL[30] WLL[29] WLL[28] WLL[27] WLL[26] WLL[25]
+   WLL[24] WLL[23] WLL[22] WLL[21] WLL[20] WLL[19] WLL[18] WLL[17] WLL[16]
+   WLL[15] WLL[14] WLL[13] WLL[12] WLL[11] WLL[10] WLL[9] WLL[8] WLL[7] WLL[6]
+   WLL[5] WLL[4] WLL[3] WLL[2] WLL[1] WLL[0] WLR[31] WLR[30] WLR[29] WLR[28]
+   WLR[27] WLR[26] WLR[25] WLR[24] WLR[23] WLR[22] WLR[21] WLR[20] WLR[19]
+   WLR[18] WLR[17] WLR[16] WLR[15] WLR[14] WLR[13] WLR[12] WLR[11] WLR[10]
+   WLR[9] WLR[8] WLR[7] WLR[6] WLR[5] WLR[4] WLR[3] WLR[2] WLR[1] WLR[0]
+   PARDB[7] PARDB[6] PARDB[5] PARDB[4] PARDB[3] PARDB[2] PARDB[1] PARDB[0] VSS
+   VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS PBRDB[3] PBRDB[2] PBRDB[1]
+   PBRDB[0] WCLKRD[1] WCLKRD[0] WCLKRDB[1] WCLKRDB[0] RDOFF WRREF
+   asdrlspkb1p64x16cm2sw0_xdec_top
Xgcen LOG0 LOG1 ACUTRK CCOR CCRDR DCLKBR MCLK LWER PARDB[7] PARDB[6] PARDB[5]
+   PARDB[4] PARDB[3] PARDB[2] PARDB[1] PARDB[0] PBRDB[3] PBRDB[2] PBRDB[1]
+   PBRDB[0] PCBR[3] PCBR[2] PCBR[1] PCBR[0] RDOFF RW_RBL SAOFF T1B WCLKRD[1]
+   WCLKRD[0] WCLKRDB[1] WCLKRDB[0] Z0B Z[2] Z[1] Z[0] ADR[5] ADR[4] ADR[3]
+   ADR[2] ADR[1] ADR[0] CLK CCWR ME LOG1 LOG1 LOG1 RME RM[3] RM[2] RM[1] RM[0]
+   LOG1 LOG1 LOG1 LOG0 LOG1 LOG0 SAEBRT STCLK STCLKWR TEST1 WE
+   asdrlspkb1p64x16cm2sw0_gcen_with_prog
Xio_rt LOG0 LOG1 Q[15] Q[14] Q[13] Q[12] Q[11] Q[10] Q[9] Q[8] Q[7] Q[6] Q[5]
+   Q[4] Q[3] Q[2] Q[1] Q[0] BB[31] BB[30] BB[29] BB[28] BB[27] BB[26] BB[25]
+   BB[24] BB[23] BB[22] BB[21] BB[20] BB[19] BB[18] BB[17] BB[16] BB[15] BB[14]
+    BB[13] BB[12] BB[11] BB[10] BB[9] BB[8] BB[7] BB[6] BB[5] BB[4] BB[3] BB[2]
+    BB[1] BB[0] BT[31] BT[30] BT[29] BT[28] BT[27] BT[26] BT[25] BT[24] BT[23]
+   BT[22] BT[21] BT[20] BT[19] BT[18] BT[17] BT[16] BT[15] BT[14] BT[13] BT[12]
+    BT[11] BT[10] BT[9] BT[8] BT[7] BT[6] BT[5] BT[4] BT[3] BT[2] BT[1] BT[0]
+   CCOR CCRDR CCWR D[15] D[14] D[13] D[12] D[11] D[10] D[9] D[8] D[7] D[6] D[5]
+    D[4] D[3] D[2] D[1] D[0] DCLKBR LWER MCLK PCBR[3] PCBR[2] PCBR[1] PCBR[0]
+   RBLRD RBLWR RW_RBL RT1 SAEBRT SAOFF STCLK STCLKWR T1B WRREF
+   asdrlspkb1p64x16cm2sw0_io_rt
.ENDS
